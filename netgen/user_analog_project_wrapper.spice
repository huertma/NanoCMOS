* NGSPICE file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt sky130_fd_pr__diode_pd2nw_05v5_5STTM9 a_n290_n290#
D0 a_n290_n290# w_n428_n428# sky130_fd_pr__diode_pd2nw_05v5 pj=1.16e+07u area=8.41e+12p
.ends

.subckt pad4diode pad3_0/m4_n10636_n5828# pad3_0/m5_n10636_n5828# VSUBS
Xsky130_fd_pr__diode_pd2nw_05v5_5STTM9_0 m1_1256_1108# sky130_fd_pr__diode_pd2nw_05v5_5STTM9
.ends

.subckt pattern_unit_small_cs_1x4
.ends

.subckt pattern_row_small_cs_5 drain_vias_0/m3_39512_0# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_n10_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_390_n10# drain_vias_0/m3_51630_0#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_790_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_390_n10#
+ drain_vias_0/m3_n4_0# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_n410_n10#
+ m4_47972_4350# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_1990_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_n410_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_1990_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_n410_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_390_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_1190_n10# drain_vias_0/m3_9164_0#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_1190_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_790_n10# drain_vias_0/m3_21282_0#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_790_n10# drain_vias_0/m3_33400_0#
+ m4_26792_3570# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_n10_n10#
+ m4_38910_4038# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_1990_n10# drain_vias_0/m3_45518_0#
+ m4_20680_3258# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_1990_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_790_n10#
+ m4_17624_3102# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_n10_n10# m4_51028_4506#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_1190_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_390_n10#
+ m4_41966_4194# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_n10_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_1190_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_390_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_n410_n10#
+ drain_vias_0/m3_54686_0# m4_5506_2634# m4_2450_2478# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_790_n10# drain_vias_0/m3_3052_0#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_790_n10# m4_8562_2790#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_n10_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_1990_n10# drain_vias_0/m3_15170_0#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_n410_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_n410_n10# m4_32798_3726#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_n10_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_1990_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_790_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_1990_n10# m4_54084_4662#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_n410_n10# drain_vias_0/m3_24338_0#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_1190_n10# pattern_unit_small_row_label_3/m5_70_3052#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_n10_n10# drain_vias_0/m3_36456_0#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_390_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_790_n10#
+ m4_23736_3414# drain_vias_0/m3_48574_0# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_n10_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_1990_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_790_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_n410_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_1990_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_n410_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_790_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_n410_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_n10_n10# m4_57140_4818#
+ m4_35854_3882# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_390_n10#
+ drain_vias_0/m3_6108_0# drain_vias_0/m3_18226_0# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_1990_n10# drain_vias_0/m3_30344_0#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_n410_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_790_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_n10_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_1190_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_n10_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_390_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_790_n10# m4_11618_2946#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_n410_n10#
Xpattern_unit_small_cs_1x4_0[0] pattern_unit_small_cs_1x4
Xpattern_unit_small_cs_1x4_0[1] pattern_unit_small_cs_1x4
Xpattern_unit_small_cs_1x4_0[2] pattern_unit_small_cs_1x4
Xpattern_unit_small_cs_1x4_0[3] pattern_unit_small_cs_1x4
.ends

.subckt pattern_row_small_cs_3 pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_1190_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_790_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_390_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m4_n410_6452# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_1590_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m4_n410_6452# m4_47972_4350#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_1190_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_790_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_n10_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_390_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_n10_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_1990_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_1590_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m4_n410_6452# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_790_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_790_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m4_n410_6452# m4_26792_3570#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_n10_n10# m4_38910_4038#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_390_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_1590_n10# m4_20680_3258#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_1190_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m4_n410_6452# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_790_n10#
+ m4_17624_3102# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_n10_n10# m4_51028_4506#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_1190_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_390_n10#
+ m4_41966_4194# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_n10_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m4_n410_6452# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_1990_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_n410_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_1590_n10#
+ m4_5506_2634# m4_2450_2478# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_790_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_790_n10# m4_8562_2790#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_n10_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m4_n410_6452#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_390_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_1590_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_1990_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m4_n410_6452#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_n410_n10# m4_32798_3726#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_n10_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_1990_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_790_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m4_n410_6452# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_1990_n10#
+ pattern_unit_small_row_label_3/m5_70_3052# m4_54084_4662# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_1590_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_n10_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m4_n410_6452#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_1590_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_790_n10# m4_23736_3414#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_1590_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_n10_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_1990_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_790_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_n410_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m4_n410_6452# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_1190_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_390_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_1990_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m4_n410_6452# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_n10_n10# m4_57140_4818#
+ m4_35854_3882# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_1590_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m4_n410_6452#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_1590_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_1990_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m4_n410_6452# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_1190_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_1990_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_390_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m4_n410_6452# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_n10_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_390_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_790_n10# m4_11618_2946#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_n410_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m4_n410_6452#
Xpattern_unit_small_cs_1x4_0[0] pattern_unit_small_cs_1x4
Xpattern_unit_small_cs_1x4_0[1] pattern_unit_small_cs_1x4
Xpattern_unit_small_cs_1x4_0[2] pattern_unit_small_cs_1x4
Xpattern_unit_small_cs_1x4_0[3] pattern_unit_small_cs_1x4
.ends

.subckt pattern_row_small_cs_1 pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_1190_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_790_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_390_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m4_n410_6452#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_790_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_1590_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m4_n410_6452# m4_47972_4350#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_1190_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_790_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_n10_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_390_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_n10_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_1990_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_1590_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m4_n410_6452# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_790_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_790_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m4_n410_6452# m4_26792_3570#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_n10_n10# m4_38910_4038#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_390_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_1590_n10# m4_20680_3258#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_1190_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m4_n410_6452# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_790_n10#
+ m4_17624_3102# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_n10_n10# m4_51028_4506#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_1190_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_390_n10#
+ m4_41966_4194# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_n10_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m4_n410_6452# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_1990_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_n410_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_1590_n10#
+ m4_5506_2634# m4_2450_2478# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_790_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_790_n10# m4_8562_2790#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_n10_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m4_n410_6452#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_390_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_1590_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_1990_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m4_n410_6452#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_n410_n10# m4_32798_3726#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_n10_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_1990_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_790_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m4_n410_6452# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_1990_n10#
+ m4_54084_4662# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_1590_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_n10_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_390_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m4_n410_6452#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_790_n10# m4_23736_3414#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_1590_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_n10_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_1990_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_790_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_n410_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m4_n410_6452# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_1190_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_390_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_1990_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m4_n410_6452# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_n10_n10# pattern_unit_small_row_label_3/m5_70_3052#
+ m4_57140_4818# m4_35854_3882# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_1590_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m4_n410_6452#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_1590_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_1990_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m4_n410_6452#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_1590_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_1190_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_1990_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_390_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m4_n410_6452# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_n10_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_390_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_790_n10# m4_11618_2946#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_n410_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m4_n410_6452#
Xpattern_unit_small_cs_1x4_0[0] pattern_unit_small_cs_1x4
Xpattern_unit_small_cs_1x4_0[1] pattern_unit_small_cs_1x4
Xpattern_unit_small_cs_1x4_0[2] pattern_unit_small_cs_1x4
Xpattern_unit_small_cs_1x4_0[3] pattern_unit_small_cs_1x4
.ends

.subckt pattern_row_small_cs pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_1190_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_790_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_1590_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_390_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_1590_n10#
+ drain_vias_0/m3_24338_0# m4_47972_4350# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_1990_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_790_n10#
+ drain_vias_0/m3_36456_0# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_1990_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_390_n10#
+ drain_vias_0/m3_48574_0# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_390_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_1190_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_1190_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_790_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_790_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_1590_n10#
+ m4_26792_3570# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_n10_n10#
+ m4_38910_4038# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_1990_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_1590_n10#
+ m4_20680_3258# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_1990_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_790_n10#
+ m4_17624_3102# drain_vias_0/m3_6108_0# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_n10_n10#
+ m4_51028_4506# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_390_n10# m4_41966_4194#
+ drain_vias_0/m3_18226_0# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_790_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_1990_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_390_n10#
+ drain_vias_0/m3_30344_0# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_1590_n10#
+ m4_5506_2634# m4_2450_2478# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_790_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_790_n10# m4_8562_2790#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_n10_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_1990_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_1590_n10#
+ drain_vias_0/m3_39512_0# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_1990_n10#
+ drain_vias_0/m3_51630_0# m4_32798_3726# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_1190_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_n10_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_1190_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_1990_n10#
+ m4_54084_4662# drain_vias_0/m3_n4_0# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_1190_n10# pattern_unit_small_row_label_3/m5_70_3052#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_n10_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_390_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_790_n10#
+ m4_23736_3414# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_790_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_390_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_1990_n10#
+ drain_vias_0/m3_9164_0# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_1190_n10# drain_vias_0/m3_21282_0#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_390_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_1190_n10# drain_vias_0/m3_33400_0#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_390_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_1990_n10# drain_vias_0/m3_45518_0#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_1190_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_n10_n10#
+ m4_57140_4818# m4_35854_3882# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_1590_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_n10_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_1590_n10# drain_vias_0/m3_54686_0#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_1190_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_1990_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_390_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_1990_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_n10_n10#
+ drain_vias_0/m3_3052_0# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_1190_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_790_n10#
+ m4_11618_2946# drain_vias_0/m3_15170_0#
Xpattern_unit_small_cs_1x4_0[0] pattern_unit_small_cs_1x4
Xpattern_unit_small_cs_1x4_0[1] pattern_unit_small_cs_1x4
Xpattern_unit_small_cs_1x4_0[2] pattern_unit_small_cs_1x4
Xpattern_unit_small_cs_1x4_0[3] pattern_unit_small_cs_1x4
.ends

.subckt pattern_row_small_cs_6 pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_1190_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_790_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_1590_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_390_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_n410_n10# m4_47972_4350#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_1190_n10# drain_vias_0/m3_6108_0#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_790_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_n10_n10# drain_vias_0/m3_18226_0#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_390_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_n10_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_390_n10#
+ drain_vias_0/m3_30344_0# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_1590_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_n10_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_1590_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_1590_n10# m4_26792_3570#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_n10_n10# m4_38910_4038#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_390_n10# drain_vias_0/m3_39512_0#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_1590_n10# m4_20680_3258#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_1190_n10# drain_vias_0/m3_51630_0#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_790_n10# m4_17624_3102#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_n410_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_n10_n10#
+ m4_51028_4506# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_390_n10# m4_41966_4194#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_n410_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_790_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_1190_n10#
+ drain_vias_0/m3_n4_0# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_n410_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_1590_n10#
+ m4_5506_2634# m4_2450_2478# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_790_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_790_n10# m4_8562_2790#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_n10_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_390_n10#
+ drain_vias_0/m3_9164_0# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_n410_n10# drain_vias_0/m3_21282_0#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_n410_n10# m4_32798_3726#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_n10_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_1190_n10#
+ drain_vias_0/m3_33400_0# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_790_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_1190_n10#
+ drain_vias_0/m3_45518_0# m4_54084_4662# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_1590_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_1190_n10#
+ pattern_unit_small_row_label_3/m5_70_3052# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_1590_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_790_n10# m4_23736_3414#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_1590_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_n10_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_390_n10#
+ drain_vias_0/m3_54686_0# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_790_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_n410_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_390_n10#
+ drain_vias_0/m3_3052_0# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_n410_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_790_n10# drain_vias_0/m3_15170_0#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_n410_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_n10_n10# m4_57140_4818#
+ m4_35854_3882# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_1590_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_n10_n10# drain_vias_0/m3_24338_0#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_1590_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_1190_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_790_n10#
+ drain_vias_0/m3_36456_0# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_390_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_1190_n10#
+ drain_vias_0/m3_48574_0# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_n410_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_1190_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_790_n10#
+ m4_11618_2946# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_n410_n10#
Xpattern_unit_small_cs_1x4_0[0] pattern_unit_small_cs_1x4
Xpattern_unit_small_cs_1x4_0[1] pattern_unit_small_cs_1x4
Xpattern_unit_small_cs_1x4_0[2] pattern_unit_small_cs_1x4
Xpattern_unit_small_cs_1x4_0[3] pattern_unit_small_cs_1x4
.ends

.subckt pattern_row_small_cs_4 pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_1590_n10#
+ drain_vias_0/m3_45518_0# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_790_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_1590_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_390_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_n410_n10# m4_47972_4350#
+ drain_vias_0/m3_54686_0# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_790_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_n10_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_390_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_n10_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_1990_n10# drain_vias_0/m3_3052_0#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_1590_n10# drain_vias_0/m3_15170_0#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_n10_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_1590_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_1590_n10# m4_26792_3570#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_n10_n10# m4_38910_4038#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_390_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_1590_n10# m4_20680_3258#
+ drain_vias_0/m3_24338_0# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_790_n10# m4_17624_3102#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_n410_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_n10_n10#
+ m4_51028_4506# drain_vias_0/m3_36456_0# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_390_n10#
+ m4_41966_4194# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_n10_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_790_n10#
+ drain_vias_0/m3_48574_0# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_390_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_1590_n10# m4_5506_2634#
+ m4_2450_2478# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_790_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_790_n10# m4_8562_2790#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_n10_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_1990_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_n410_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_n410_n10# m4_32798_3726#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_n10_n10# drain_vias_0/m3_6108_0#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_1990_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_790_n10# drain_vias_0/m3_18226_0#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_1990_n10# m4_54084_4662#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_n410_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_1590_n10#
+ drain_vias_0/m3_30344_0# pattern_unit_small_row_label_3/m5_70_3052# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_1590_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_790_n10# m4_23736_3414#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_1590_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_n10_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_1990_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_790_n10# drain_vias_0/m3_39512_0#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_n410_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_1990_n10# drain_vias_0/m3_51630_0#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_n410_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_790_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_n410_n10# drain_vias_0/m3_n4_0#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_n10_n10# m4_57140_4818#
+ m4_35854_3882# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_1590_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_n10_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_1590_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_n410_n10#
+ drain_vias_0/m3_9164_0# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_1990_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_390_n10# drain_vias_0/m3_21282_0#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_1990_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_n410_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_390_n10#
+ drain_vias_0/m3_33400_0# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_790_n10#
+ m4_11618_2946# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_n410_n10#
Xpattern_unit_small_cs_1x4_0[0] pattern_unit_small_cs_1x4
Xpattern_unit_small_cs_1x4_0[1] pattern_unit_small_cs_1x4
Xpattern_unit_small_cs_1x4_0[2] pattern_unit_small_cs_1x4
Xpattern_unit_small_cs_1x4_0[3] pattern_unit_small_cs_1x4
.ends

.subckt pattern_row_small_cs_2 pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_1190_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_790_n10# drain_vias_0/m3_30344_0#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_1590_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_790_n10#
+ drain_vias_0/m3_24338_0# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_n410_n10# m4_47972_4350#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_1190_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_790_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_n10_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_1990_n10#
+ drain_vias_0/m3_3052_0# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_n10_n10# drain_vias_0/m3_48574_0#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_1990_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_1590_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_n10_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_1590_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_1590_n10# m4_26792_3570#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_n10_n10# m4_38910_4038#
+ drain_vias_0/m3_21282_0# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_1590_n10# m4_20680_3258#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_1190_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_790_n10# m4_17624_3102#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_n410_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_n10_n10#
+ m4_51028_4506# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_1190_n10#
+ drain_vias_0/m3_n4_0# m4_41966_4194# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_n10_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_1190_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_1990_n10#
+ drain_vias_0/m3_45518_0# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_1590_n10# m4_5506_2634#
+ m4_2450_2478# drain_vias_0/m3_39512_0# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_1590_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_790_n10#
+ m4_8562_2790# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_n10_n10#
+ drain_vias_0/m3_18226_0# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_1590_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_1990_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_n410_n10#
+ m4_32798_3726# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_1190_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_n10_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_1190_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_1990_n10#
+ pattern_unit_small_row_label_3/m5_70_3052# m4_54084_4662# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_1590_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_n10_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_1590_n10#
+ drain_vias_0/m3_36456_0# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_790_n10#
+ m4_23736_3414# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_790_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_n10_n10#
+ drain_vias_0/m3_15170_0# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_n410_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[3]/m3_1190_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_n410_n10#
+ drain_vias_0/m3_9164_0# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[2]/m3_1190_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_n410_n10#
+ drain_vias_0/m3_54686_0# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_1990_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[0]/m3_1190_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_n10_n10#
+ m4_57140_4818# m4_35854_3882# drain_vias_0/m3_33400_0# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[1]/m3_1590_n10# pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[3]/m3_1990_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_n410_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_790_n10# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[3]/m3_n10_n10# drain_vias_0/m3_6108_0#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[2]/m3_1190_n10# pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_0[3]/pattern_unit_small_cs_0[3]/m3_n10_n10# pattern_unit_small_cs_1x4_0[0]/pattern_unit_small_cs_0[1]/m3_n410_n10#
+ drain_vias_0/m3_51630_0# pattern_unit_small_cs_1x4_0[2]/pattern_unit_small_cs_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_790_n10# m4_11618_2946#
+ pattern_unit_small_cs_1x4_0[1]/pattern_unit_small_cs_0[0]/m3_n410_n10#
Xpattern_unit_small_cs_1x4_0[0] pattern_unit_small_cs_1x4
Xpattern_unit_small_cs_1x4_0[1] pattern_unit_small_cs_1x4
Xpattern_unit_small_cs_1x4_0[2] pattern_unit_small_cs_1x4
Xpattern_unit_small_cs_1x4_0[3] pattern_unit_small_cs_1x4
.ends

.subckt pattern_array_small_cs m1_26152_78390# m1_49988_78390# pattern_row_small_cs_6_0/m4_5506_2634#
+ pattern_row_small_cs_2_0/m4_32798_3726# pattern_row_small_cs_3_0/m4_11618_2946#
+ m1_53844_78390# pattern_row_small_cs_4_0/m4_2450_2478# pattern_row_small_cs_1_0/m4_51028_4506#
+ m1_28408_78390# m1_19240_78390# pattern_row_small_cs_1_0/m4_41966_4194# m1_7122_78390#
+ pattern_row_small_cs_1_0/m4_5506_2634# m1_44382_78390# pattern_row_small_cs_2_0/m4_54084_4662#
+ pattern_row_small_cs_6_0/m4_8562_2790# m1_10578_78390# m1_41326_78390# m1_8722_78390#
+ pattern_row_small_cs_3_0/m4_57140_4818# m1_15234_78390# pattern_row_small_cs_3_0/m4_35854_3882#
+ m1_37470_78390# pattern_row_small_cs_5_0/m4_26792_3570# m1_50388_78390# pattern_row_small_cs_0/m4_23736_3414#
+ pattern_row_small_cs_4_0/m4_20680_3258# pattern_row_small_cs_5_0/m4_38910_4038#
+ pattern_row_small_cs_6_0/m4_23736_3414# m1_24296_78390# m1_34414_78390# pattern_row_small_cs_1_0/m4_8562_2790#
+ pattern_row_small_cs_0/m4_5506_2634# pattern_row_small_cs_1_0/m4_20680_3258# pattern_row_small_cs_4_0/m4_17624_3102#
+ pattern_row_small_cs_3_0/m4_23736_3414# pattern_row_small_cs_1_0/m4_2450_2478# pattern_row_small_cs_0/m4_26792_3570#
+ pattern_row_small_cs_1_0/m4_17624_3102# pattern_row_small_cs_0/m4_38910_4038# m1_12834_78390#
+ pattern_row_small_cs_6_0/m4_32798_3726# pattern_row_small_cs_4_0/m4_47972_4350#
+ m1_5266_78390# m1_30408_78390# m1_52644_78390# m1_21240_78390# m1_21896_78390# m1_57300_78390#
+ pattern_row_small_cs_5_0/m4_51028_4506# m1_26552_78390# pattern_row_small_cs_5_0/m4_41966_4194#
+ pattern_row_small_cs_4_0/m4_11618_2946# pattern_row_small_cs_0/m4_8562_2790# pattern_row_small_cs_0/m4_2450_2478#
+ m1_43182_78390# pattern_row_small_cs_6_0/m4_54084_4662# pattern_row_small_cs_0/m4_51028_4506#
+ pattern_row_small_cs_1_0/m4_32798_3726# m1_28808_78390# pattern_row_small_cs_0/m4_41966_4194#
+ m1_19640_78390# m1_40126_78390# m1_7522_78390# pattern_row_small_cs_2_0/m4_5506_2634#
+ m1_14034_78390# m1_44782_78390# pattern_row_small_cs_1_0/m4_54084_4662# m1_10978_78390#
+ m1_23096_78390# m1_41726_78390# m1_59156_78390# m1_37870_78390# pattern_row_small_cs_2_0/m4_57140_4818#
+ pattern_row_small_cs_2_0/m4_35854_3882# m1_50788_78390# pattern_row_small_cs_5_0/pattern_unit_small_row_label_3/m5_70_3052#
+ pattern_row_small_cs_2_0/m4_8562_2790# pattern_row_small_cs_4_0/m4_26792_3570# m1_34814_78390#
+ pattern_row_small_cs_5_0/m4_2450_2478# m1_4066_78390# pattern_row_small_cs_4_0/m4_38910_4038#
+ m1_20040_78390# m1_25352_78390# m1_56100_78390# m1_5666_78390# m1_12178_78390# pattern_row_small_cs_5_0/m4_32798_3726#
+ pattern_row_small_cs_3_0/m4_47972_4350# m1_26952_78390# m1_39070_78390# m1_57700_78390#
+ pattern_row_small_cs_5_0/m4_11618_2946# pattern_row_small_cs_4_0/m4_51028_4506#
+ pattern_row_small_cs_4_0/m4_41966_4194# m1_36014_78390# m1_43582_78390# pattern_row_small_cs_0/m4_32798_3726#
+ pattern_row_small_cs_3_0/m4_5506_2634# pattern_row_small_cs_5_0/m4_54084_4662# m1_40526_78390#
+ pattern_row_small_cs_5_0/m4_20680_3258# pattern_row_small_cs_2_0/m4_2450_2478# m1_7922_78390#
+ m1_14434_78390# pattern_row_small_cs_6_0/m4_57140_4818# pattern_row_small_cs_2_0/m4_20680_3258#
+ pattern_row_small_cs_5_0/m4_17624_3102# pattern_row_small_cs_6_0/m4_35854_3882#
+ pattern_row_small_cs_4_0/m4_23736_3414# m1_54244_78390# pattern_row_small_cs_0/m4_54084_4662#
+ m1_23496_78390# pattern_row_small_cs_2_0/m4_17624_3102# m1_59556_78390# pattern_row_small_cs_1_0/m4_23736_3414#
+ pattern_row_small_cs_3_0/m4_8562_2790# pattern_row_small_cs_1_0/m4_57140_4818# pattern_row_small_cs_1_0/m4_35854_3882#
+ m1_4466_78390# pattern_row_small_cs_3_0/m4_26792_3570# m1_9122_78390# m1_20440_78390#
+ m1_9778_78390# pattern_row_small_cs_3_0/m4_38910_4038# m1_56500_78390# pattern_row_small_cs_2_0/pattern_unit_small_row_label_3/m5_70_3052#
+ m1_25752_78390# pattern_row_small_cs_6_0/m4_11618_2946# m1_18840_78390# m1_39470_78390#
+ pattern_row_small_cs_4_0/m4_32798_3726# pattern_row_small_cs_2_0/m4_47972_4350#
+ m1_6722_78390# pattern_row_small_cs_0/pattern_unit_small_row_label_3/m5_70_3052#
+ m1_13234_78390# m1_36414_78390# m1_43982_78390# m1_49188_78390# pattern_row_small_cs_3_0/m4_51028_4506#
+ pattern_row_small_cs_4_0/m4_5506_2634# pattern_row_small_cs_6_0/m4_2450_2478# pattern_row_small_cs_3_0/m4_41966_4194#
+ m1_22296_78390# m1_40926_78390# m1_53044_78390# m1_58356_78390# pattern_row_small_cs_4_0/m4_54084_4662#
+ pattern_row_small_cs_1_0/m4_11618_2946# m1_14834_78390# pattern_row_small_cs_5_0/m4_57140_4818#
+ m1_23896_78390# m1_54644_78390# pattern_row_small_cs_4_0/pattern_unit_small_row_label_3/m5_70_3052#
+ pattern_row_small_cs_5_0/m4_35854_3882# m1_29208_78390# m1_59956_78390# pattern_row_small_cs_4_0/m4_8562_2790#
+ pattern_row_small_cs_0/m4_57140_4818# m1_45182_78390# m1_55300_78390# pattern_row_small_cs_0/m4_35854_3882#
+ pattern_row_small_cs_0/m4_11618_2946# m1_42126_78390# m1_4866_78390# m1_11378_78390#
+ m1_20840_78390# pattern_row_small_cs_3_0/m4_2450_2478# pattern_row_small_cs_2_0/m4_26792_3570#
+ m1_38270_78390# m1_56900_78390# pattern_row_small_cs_6_0/m4_47972_4350# m1_51188_78390#
+ pattern_row_small_cs_2_0/m4_38910_4038# pattern_row_small_cs_0/m4_20680_3258# m1_35214_78390#
+ pattern_row_small_cs_1_0/pattern_unit_small_row_label_3/m5_70_3052# pattern_row_small_cs_6_0/m4_20680_3258#
+ pattern_row_small_cs_3_0/m4_20680_3258# pattern_row_small_cs_0/m4_17624_3102# m1_60356_78390#
+ pattern_row_small_cs_6_0/m4_17624_3102# pattern_row_small_cs_5_0/m4_23736_3414#
+ pattern_row_small_cs_1_0/m4_47972_4350# pattern_row_small_cs_3_0/m4_32798_3726#
+ m1_13634_78390# m1_49588_78390# pattern_row_small_cs_3_0/m4_17624_3102# m1_6066_78390#
+ pattern_row_small_cs_5_0/m4_5506_2634# pattern_row_small_cs_2_0/m4_23736_3414# pattern_row_small_cs_2_0/m4_51028_4506#
+ m1_53444_78390# pattern_row_small_cs_2_0/m4_41966_4194# pattern_row_small_cs_2_0/m4_11618_2946#
+ m1_22696_78390# m1_28008_78390# m1_58756_78390# m1_27352_78390# pattern_row_small_cs_3_0/m4_54084_4662#
+ m1_29608_78390# pattern_row_small_cs_4_0/m4_57140_4818# pattern_row_small_cs_5_0/m4_8562_2790#
+ m1_3666_78390# pattern_row_small_cs_4_0/m4_35854_3882# m1_10178_78390# m1_8322_78390#
+ pattern_row_small_cs_6_0/m4_26792_3570# m1_37070_78390# m1_45582_78390# m1_55700_78390#
+ m1_24952_78390# pattern_row_small_cs_6_0/m4_38910_4038# m1_34014_78390# m1_42526_78390#
+ m1_11778_78390# m1_38670_78390# pattern_row_small_cs_1_0/m4_26792_3570# m1_51588_78390#
+ pattern_row_small_cs_6_0/pattern_unit_small_row_label_3/m5_70_3052# pattern_row_small_cs_5_0/m4_47972_4350#
+ m1_35614_78390# pattern_row_small_cs_1_0/m4_38910_4038# pattern_row_small_cs_6_0/m4_51028_4506#
+ m1_30008_78390# m1_52244_78390# m1_60756_78390# pattern_row_small_cs_3_0/pattern_unit_small_row_label_3/m5_70_3052#
+ pattern_row_small_cs_6_0/m4_41966_4194# pattern_row_small_cs_0/m4_47972_4350#
Xpattern_row_small_cs_5_0 m1_45182_78390# m1_50788_78390# m1_37470_78390# m1_14034_78390#
+ m1_34814_78390# m1_57300_78390# m1_59556_78390# m1_28808_78390# m1_5666_78390# m1_28008_78390#
+ pattern_row_small_cs_5_0/m4_47972_4350# m1_59956_78390# m1_12178_78390# m1_38270_78390#
+ m1_40126_78390# m1_10178_78390# m1_24296_78390# m1_7522_78390# m1_52244_78390# m1_55700_78390#
+ m1_53044_78390# m1_36414_78390# m1_8322_78390# m1_14834_78390# m1_20440_78390# m1_34414_78390#
+ m1_10978_78390# m1_26952_78390# m1_56500_78390# m1_39070_78390# pattern_row_small_cs_5_0/m4_26792_3570#
+ m1_28408_78390# pattern_row_small_cs_5_0/m4_38910_4038# m1_25752_78390# m1_45582_78390#
+ m1_51188_78390# pattern_row_small_cs_5_0/m4_20680_3258# m1_29608_78390# m1_57700_78390#
+ m1_35214_78390# pattern_row_small_cs_5_0/m4_17624_3102# m1_9778_78390# m1_7122_78390#
+ pattern_row_small_cs_5_0/m4_51028_4506# m1_41726_78390# m1_4466_78390# pattern_row_small_cs_5_0/m4_41966_4194#
+ m1_21896_78390# m1_52644_78390# m1_29208_78390# m1_53844_78390# m1_6066_78390# m1_49988_78390#
+ m1_34014_78390# m1_60356_78390# pattern_row_small_cs_5_0/m4_5506_2634# pattern_row_small_cs_5_0/m4_2450_2478#
+ m1_43982_78390# m1_7922_78390# m1_8722_78390# m1_53444_78390# pattern_row_small_cs_5_0/m4_8562_2790#
+ m1_25352_78390# m1_22696_78390# m1_15234_78390# m1_20840_78390# m1_43182_78390#
+ m1_27352_78390# m1_55300_78390# pattern_row_small_cs_5_0/m4_32798_3726# m1_4066_78390#
+ m1_11378_78390# m1_39470_78390# m1_49588_78390# m1_26152_78390# m1_23496_78390#
+ m1_51588_78390# pattern_row_small_cs_5_0/m4_54084_4662# m1_3666_78390# m1_30008_78390#
+ m1_35614_78390# pattern_row_small_cs_5_0/pattern_unit_small_row_label_3/m5_70_3052#
+ m1_43582_78390# m1_42126_78390# m1_40926_78390# m1_4866_78390# pattern_row_small_cs_5_0/m4_23736_3414#
+ m1_54244_78390# m1_50388_78390# m1_22296_78390# m1_19640_78390# m1_60756_78390#
+ m1_12834_78390# m1_44382_78390# m1_44782_78390# m1_24952_78390# m1_13634_78390#
+ m1_9122_78390# m1_56900_78390# m1_37070_78390# m1_59156_78390# m1_23096_78390# m1_21240_78390#
+ m1_49188_78390# m1_5266_78390# m1_40526_78390# pattern_row_small_cs_5_0/m4_57140_4818#
+ pattern_row_small_cs_5_0/m4_35854_3882# m1_37870_78390# m1_11778_78390# m1_23896_78390#
+ m1_19240_78390# m1_30408_78390# m1_36014_78390# m1_58356_78390# m1_14434_78390#
+ m1_41326_78390# m1_42526_78390# m1_13234_78390# m1_10578_78390# m1_26552_78390#
+ m1_54644_78390# m1_58756_78390# m1_6722_78390# m1_56100_78390# m1_38670_78390# m1_20040_78390#
+ pattern_row_small_cs_5_0/m4_11618_2946# m1_18840_78390# pattern_row_small_cs_5
Xpattern_row_small_cs_3_0 m1_45182_78390# m1_50788_78390# m1_37470_78390# m1_14034_78390#
+ m1_57300_78390# m1_34814_78390# m1_59556_78390# m1_35214_78390# m1_28808_78390#
+ m1_5666_78390# m1_28008_78390# m1_50388_78390# pattern_row_small_cs_3_0/m4_47972_4350#
+ m1_59956_78390# m1_12178_78390# m1_38270_78390# m1_40126_78390# m1_10178_78390#
+ m1_24296_78390# m1_7522_78390# m1_52244_78390# m1_55700_78390# m1_53044_78390# m1_36414_78390#
+ m1_8322_78390# m1_14834_78390# m1_20440_78390# m1_7922_78390# m1_34414_78390# m1_10978_78390#
+ m1_26952_78390# m1_56500_78390# m1_39070_78390# m1_23096_78390# pattern_row_small_cs_3_0/m4_26792_3570#
+ m1_28408_78390# pattern_row_small_cs_3_0/m4_38910_4038# m1_25752_78390# m1_45582_78390#
+ m1_51188_78390# pattern_row_small_cs_3_0/m4_20680_3258# m1_29608_78390# m1_57700_78390#
+ m1_38270_78390# m1_35214_78390# pattern_row_small_cs_3_0/m4_17624_3102# m1_9778_78390#
+ m1_7122_78390# pattern_row_small_cs_3_0/m4_51028_4506# m1_41726_78390# m1_4466_78390#
+ pattern_row_small_cs_3_0/m4_41966_4194# m1_21896_78390# m1_52644_78390# m1_29208_78390#
+ m1_53444_78390# m1_53844_78390# m1_6066_78390# m1_49988_78390# m1_34014_78390# m1_60356_78390#
+ pattern_row_small_cs_3_0/m4_5506_2634# pattern_row_small_cs_3_0/m4_2450_2478# m1_43982_78390#
+ m1_7922_78390# m1_8722_78390# m1_53444_78390# pattern_row_small_cs_3_0/m4_8562_2790#
+ m1_25352_78390# m1_10978_78390# m1_22696_78390# m1_15234_78390# m1_20840_78390#
+ m1_43182_78390# m1_27352_78390# m1_26152_78390# m1_55300_78390# pattern_row_small_cs_3_0/m4_32798_3726#
+ m1_4066_78390# m1_11378_78390# m1_39470_78390# m1_49588_78390# m1_26152_78390# m1_23496_78390#
+ m1_41326_78390# m1_51588_78390# pattern_row_small_cs_3_0/pattern_unit_small_row_label_3/m5_70_3052#
+ pattern_row_small_cs_3_0/m4_54084_4662# m1_3666_78390# m1_30008_78390# m1_35614_78390#
+ m1_43582_78390# m1_56500_78390# m1_42126_78390# m1_40926_78390# m1_4866_78390# pattern_row_small_cs_3_0/m4_23736_3414#
+ m1_54244_78390# m1_50388_78390# m1_22296_78390# m1_19640_78390# m1_60756_78390#
+ m1_12834_78390# m1_44382_78390# m1_44782_78390# m1_24952_78390# m1_13634_78390#
+ m1_14034_78390# m1_9122_78390# m1_56900_78390# m1_37070_78390# m1_59156_78390# m1_23096_78390#
+ m1_21240_78390# m1_49188_78390# m1_29208_78390# m1_5266_78390# m1_40526_78390# pattern_row_small_cs_3_0/m4_57140_4818#
+ pattern_row_small_cs_3_0/m4_35854_3882# m1_37870_78390# m1_11778_78390# m1_44382_78390#
+ m1_23896_78390# m1_19240_78390# m1_30408_78390# m1_36014_78390# m1_59556_78390#
+ m1_58356_78390# m1_14434_78390# m1_41326_78390# m1_42526_78390# m1_13234_78390#
+ m1_10578_78390# m1_26552_78390# m1_4866_78390# m1_54644_78390# m1_58756_78390# m1_6722_78390#
+ m1_56100_78390# m1_38670_78390# m1_20040_78390# pattern_row_small_cs_3_0/m4_11618_2946#
+ m1_18840_78390# m1_20040_78390# pattern_row_small_cs_3
Xpattern_row_small_cs_1_0 m1_45182_78390# m1_50788_78390# m1_37470_78390# m1_14034_78390#
+ m1_57300_78390# m1_34814_78390# m1_34414_78390# m1_59556_78390# m1_28808_78390#
+ m1_5666_78390# m1_28008_78390# m1_49588_78390# pattern_row_small_cs_1_0/m4_47972_4350#
+ m1_59956_78390# m1_12178_78390# m1_38270_78390# m1_40126_78390# m1_10178_78390#
+ m1_24296_78390# m1_7522_78390# m1_52244_78390# m1_55700_78390# m1_53044_78390# m1_36414_78390#
+ m1_8322_78390# m1_14834_78390# m1_20440_78390# m1_7122_78390# m1_34414_78390# m1_10978_78390#
+ m1_26952_78390# m1_56500_78390# m1_39070_78390# m1_22296_78390# pattern_row_small_cs_1_0/m4_26792_3570#
+ m1_28408_78390# pattern_row_small_cs_1_0/m4_38910_4038# m1_25752_78390# m1_45582_78390#
+ m1_51188_78390# pattern_row_small_cs_1_0/m4_20680_3258# m1_29608_78390# m1_57700_78390#
+ m1_37470_78390# m1_35214_78390# pattern_row_small_cs_1_0/m4_17624_3102# m1_9778_78390#
+ m1_7122_78390# pattern_row_small_cs_1_0/m4_51028_4506# m1_41726_78390# m1_4466_78390#
+ pattern_row_small_cs_1_0/m4_41966_4194# m1_21896_78390# m1_52644_78390# m1_29208_78390#
+ m1_52644_78390# m1_53844_78390# m1_6066_78390# m1_49988_78390# m1_34014_78390# m1_60356_78390#
+ pattern_row_small_cs_1_0/m4_5506_2634# pattern_row_small_cs_1_0/m4_2450_2478# m1_43982_78390#
+ m1_7922_78390# m1_8722_78390# m1_53444_78390# pattern_row_small_cs_1_0/m4_8562_2790#
+ m1_25352_78390# m1_10178_78390# m1_22696_78390# m1_15234_78390# m1_20840_78390#
+ m1_43182_78390# m1_27352_78390# m1_25352_78390# m1_55300_78390# pattern_row_small_cs_1_0/m4_32798_3726#
+ m1_4066_78390# m1_11378_78390# m1_39470_78390# m1_49588_78390# m1_26152_78390# m1_23496_78390#
+ m1_40526_78390# m1_51588_78390# pattern_row_small_cs_1_0/m4_54084_4662# m1_3666_78390#
+ m1_30008_78390# m1_35614_78390# m1_43582_78390# m1_42126_78390# m1_40926_78390#
+ m1_55700_78390# m1_4866_78390# pattern_row_small_cs_1_0/m4_23736_3414# m1_54244_78390#
+ m1_50388_78390# m1_22296_78390# m1_19640_78390# m1_60756_78390# m1_12834_78390#
+ m1_44382_78390# m1_44782_78390# m1_24952_78390# m1_13634_78390# m1_13234_78390#
+ m1_9122_78390# m1_56900_78390# m1_37070_78390# m1_59156_78390# m1_23096_78390# m1_21240_78390#
+ m1_49188_78390# m1_28408_78390# m1_5266_78390# m1_40526_78390# pattern_row_small_cs_1_0/pattern_unit_small_row_label_3/m5_70_3052#
+ pattern_row_small_cs_1_0/m4_57140_4818# pattern_row_small_cs_1_0/m4_35854_3882#
+ m1_37870_78390# m1_11778_78390# m1_43582_78390# m1_23896_78390# m1_19240_78390#
+ m1_30408_78390# m1_58756_78390# m1_36014_78390# m1_58356_78390# m1_14434_78390#
+ m1_41326_78390# m1_42526_78390# m1_13234_78390# m1_10578_78390# m1_26552_78390#
+ m1_4066_78390# m1_54644_78390# m1_58756_78390# m1_6722_78390# m1_56100_78390# m1_38670_78390#
+ m1_20040_78390# pattern_row_small_cs_1_0/m4_11618_2946# m1_18840_78390# m1_19240_78390#
+ pattern_row_small_cs_1
Xpattern_row_small_cs_0 m1_45182_78390# m1_50788_78390# m1_37470_78390# m1_14034_78390#
+ m1_34814_78390# m1_57300_78390# m1_59556_78390# m1_28808_78390# m1_5666_78390# m1_28008_78390#
+ pattern_row_small_cs_0/m4_47972_4350# m1_59956_78390# m1_12178_78390# m1_38270_78390#
+ m1_40126_78390# m1_10178_78390# m1_24296_78390# m1_7522_78390# m1_52244_78390# m1_55700_78390#
+ m1_53044_78390# m1_36414_78390# m1_8322_78390# m1_14834_78390# m1_20440_78390# m1_34414_78390#
+ m1_10978_78390# m1_26952_78390# m1_56500_78390# m1_39070_78390# pattern_row_small_cs_0/m4_26792_3570#
+ m1_28408_78390# pattern_row_small_cs_0/m4_38910_4038# m1_25752_78390# m1_45582_78390#
+ m1_51188_78390# pattern_row_small_cs_0/m4_20680_3258# m1_29608_78390# m1_57700_78390#
+ m1_35214_78390# pattern_row_small_cs_0/m4_17624_3102# m1_9778_78390# m1_7122_78390#
+ pattern_row_small_cs_0/m4_51028_4506# m1_41726_78390# m1_4466_78390# pattern_row_small_cs_0/m4_41966_4194#
+ m1_21896_78390# m1_52644_78390# m1_29208_78390# m1_53844_78390# m1_6066_78390# m1_49988_78390#
+ m1_34014_78390# m1_60356_78390# pattern_row_small_cs_0/m4_5506_2634# pattern_row_small_cs_0/m4_2450_2478#
+ m1_43982_78390# m1_7922_78390# m1_8722_78390# m1_53444_78390# pattern_row_small_cs_0/m4_8562_2790#
+ m1_25352_78390# m1_22696_78390# m1_15234_78390# m1_20840_78390# m1_43182_78390#
+ m1_27352_78390# m1_55300_78390# pattern_row_small_cs_0/m4_32798_3726# m1_4066_78390#
+ m1_11378_78390# m1_39470_78390# m1_49588_78390# m1_26152_78390# m1_23496_78390#
+ m1_51588_78390# pattern_row_small_cs_0/m4_54084_4662# m1_3666_78390# m1_30008_78390#
+ m1_35614_78390# pattern_row_small_cs_0/pattern_unit_small_row_label_3/m5_70_3052#
+ m1_43582_78390# m1_42126_78390# m1_40926_78390# m1_4866_78390# pattern_row_small_cs_0/m4_23736_3414#
+ m1_54244_78390# m1_50388_78390# m1_22296_78390# m1_19640_78390# m1_60756_78390#
+ m1_12834_78390# m1_44382_78390# m1_44782_78390# m1_24952_78390# m1_13634_78390#
+ m1_9122_78390# m1_56900_78390# m1_37070_78390# m1_59156_78390# m1_23096_78390# m1_21240_78390#
+ m1_49188_78390# m1_5266_78390# m1_40526_78390# pattern_row_small_cs_0/m4_57140_4818#
+ pattern_row_small_cs_0/m4_35854_3882# m1_37870_78390# m1_11778_78390# m1_23896_78390#
+ m1_19240_78390# m1_30408_78390# m1_36014_78390# m1_58356_78390# m1_14434_78390#
+ m1_41326_78390# m1_42526_78390# m1_13234_78390# m1_10578_78390# m1_26552_78390#
+ m1_54644_78390# m1_58756_78390# m1_6722_78390# m1_56100_78390# m1_38670_78390# m1_20040_78390#
+ pattern_row_small_cs_0/m4_11618_2946# m1_18840_78390# pattern_row_small_cs
Xpattern_row_small_cs_6_0 m1_45182_78390# m1_50788_78390# m1_37470_78390# m1_14034_78390#
+ m1_34814_78390# m1_57300_78390# m1_59556_78390# m1_28808_78390# m1_5666_78390# m1_28008_78390#
+ pattern_row_small_cs_6_0/m4_47972_4350# m1_59956_78390# m1_12178_78390# m1_38270_78390#
+ m1_40126_78390# m1_10178_78390# m1_24296_78390# m1_7522_78390# m1_52244_78390# m1_55700_78390#
+ m1_53044_78390# m1_36414_78390# m1_8322_78390# m1_14834_78390# m1_20440_78390# m1_34414_78390#
+ m1_10978_78390# m1_26952_78390# m1_56500_78390# m1_39070_78390# pattern_row_small_cs_6_0/m4_26792_3570#
+ m1_28408_78390# pattern_row_small_cs_6_0/m4_38910_4038# m1_25752_78390# m1_45582_78390#
+ m1_51188_78390# pattern_row_small_cs_6_0/m4_20680_3258# m1_29608_78390# m1_57700_78390#
+ m1_35214_78390# pattern_row_small_cs_6_0/m4_17624_3102# m1_9778_78390# m1_7122_78390#
+ pattern_row_small_cs_6_0/m4_51028_4506# m1_41726_78390# m1_4466_78390# pattern_row_small_cs_6_0/m4_41966_4194#
+ m1_21896_78390# m1_52644_78390# m1_29208_78390# m1_53844_78390# m1_6066_78390# m1_49988_78390#
+ m1_34014_78390# m1_60356_78390# pattern_row_small_cs_6_0/m4_5506_2634# pattern_row_small_cs_6_0/m4_2450_2478#
+ m1_43982_78390# m1_7922_78390# m1_8722_78390# m1_53444_78390# pattern_row_small_cs_6_0/m4_8562_2790#
+ m1_25352_78390# m1_22696_78390# m1_15234_78390# m1_20840_78390# m1_43182_78390#
+ m1_27352_78390# m1_55300_78390# pattern_row_small_cs_6_0/m4_32798_3726# m1_4066_78390#
+ m1_11378_78390# m1_39470_78390# m1_49588_78390# m1_26152_78390# m1_23496_78390#
+ m1_51588_78390# pattern_row_small_cs_6_0/m4_54084_4662# m1_3666_78390# m1_30008_78390#
+ m1_35614_78390# pattern_row_small_cs_6_0/pattern_unit_small_row_label_3/m5_70_3052#
+ m1_43582_78390# m1_42126_78390# m1_40926_78390# m1_4866_78390# pattern_row_small_cs_6_0/m4_23736_3414#
+ m1_54244_78390# m1_50388_78390# m1_22296_78390# m1_19640_78390# m1_60756_78390#
+ m1_12834_78390# m1_44382_78390# m1_44782_78390# m1_24952_78390# m1_13634_78390#
+ m1_9122_78390# m1_56900_78390# m1_37070_78390# m1_59156_78390# m1_23096_78390# m1_21240_78390#
+ m1_49188_78390# m1_5266_78390# m1_40526_78390# pattern_row_small_cs_6_0/m4_57140_4818#
+ pattern_row_small_cs_6_0/m4_35854_3882# m1_37870_78390# m1_11778_78390# m1_23896_78390#
+ m1_19240_78390# m1_30408_78390# m1_36014_78390# m1_58356_78390# m1_14434_78390#
+ m1_41326_78390# m1_42526_78390# m1_13234_78390# m1_10578_78390# m1_26552_78390#
+ m1_54644_78390# m1_58756_78390# m1_6722_78390# m1_56100_78390# m1_38670_78390# m1_20040_78390#
+ pattern_row_small_cs_6_0/m4_11618_2946# m1_18840_78390# pattern_row_small_cs_6
Xpattern_row_small_cs_4_0 m1_45182_78390# m1_50788_78390# m1_37470_78390# m1_14034_78390#
+ m1_34814_78390# m1_57300_78390# m1_59556_78390# m1_28808_78390# m1_5666_78390# m1_28008_78390#
+ pattern_row_small_cs_4_0/m4_47972_4350# m1_59956_78390# m1_12178_78390# m1_38270_78390#
+ m1_40126_78390# m1_10178_78390# m1_24296_78390# m1_7522_78390# m1_52244_78390# m1_55700_78390#
+ m1_53044_78390# m1_36414_78390# m1_8322_78390# m1_14834_78390# m1_20440_78390# m1_34414_78390#
+ m1_10978_78390# m1_26952_78390# m1_56500_78390# m1_39070_78390# pattern_row_small_cs_4_0/m4_26792_3570#
+ m1_28408_78390# pattern_row_small_cs_4_0/m4_38910_4038# m1_25752_78390# m1_45582_78390#
+ m1_51188_78390# pattern_row_small_cs_4_0/m4_20680_3258# m1_29608_78390# m1_57700_78390#
+ m1_35214_78390# pattern_row_small_cs_4_0/m4_17624_3102# m1_9778_78390# m1_7122_78390#
+ pattern_row_small_cs_4_0/m4_51028_4506# m1_41726_78390# m1_4466_78390# pattern_row_small_cs_4_0/m4_41966_4194#
+ m1_21896_78390# m1_52644_78390# m1_29208_78390# m1_53844_78390# m1_6066_78390# m1_49988_78390#
+ m1_34014_78390# m1_60356_78390# pattern_row_small_cs_4_0/m4_5506_2634# pattern_row_small_cs_4_0/m4_2450_2478#
+ m1_43982_78390# m1_7922_78390# m1_8722_78390# m1_53444_78390# pattern_row_small_cs_4_0/m4_8562_2790#
+ m1_25352_78390# m1_22696_78390# m1_15234_78390# m1_20840_78390# m1_43182_78390#
+ m1_27352_78390# m1_55300_78390# pattern_row_small_cs_4_0/m4_32798_3726# m1_4066_78390#
+ m1_11378_78390# m1_39470_78390# m1_49588_78390# m1_26152_78390# m1_23496_78390#
+ m1_51588_78390# pattern_row_small_cs_4_0/m4_54084_4662# m1_3666_78390# m1_30008_78390#
+ m1_35614_78390# pattern_row_small_cs_4_0/pattern_unit_small_row_label_3/m5_70_3052#
+ m1_43582_78390# m1_42126_78390# m1_40926_78390# m1_4866_78390# pattern_row_small_cs_4_0/m4_23736_3414#
+ m1_54244_78390# m1_50388_78390# m1_22296_78390# m1_19640_78390# m1_60756_78390#
+ m1_12834_78390# m1_44382_78390# m1_44782_78390# m1_24952_78390# m1_13634_78390#
+ m1_9122_78390# m1_56900_78390# m1_37070_78390# m1_59156_78390# m1_23096_78390# m1_21240_78390#
+ m1_49188_78390# m1_5266_78390# m1_40526_78390# pattern_row_small_cs_4_0/m4_57140_4818#
+ pattern_row_small_cs_4_0/m4_35854_3882# m1_37870_78390# m1_11778_78390# m1_23896_78390#
+ m1_19240_78390# m1_30408_78390# m1_36014_78390# m1_58356_78390# m1_14434_78390#
+ m1_41326_78390# m1_42526_78390# m1_13234_78390# m1_10578_78390# m1_26552_78390#
+ m1_54644_78390# m1_58756_78390# m1_6722_78390# m1_56100_78390# m1_38670_78390# m1_20040_78390#
+ pattern_row_small_cs_4_0/m4_11618_2946# m1_18840_78390# pattern_row_small_cs_4
Xpattern_row_small_cs_2_0 m1_45182_78390# m1_50788_78390# m1_37470_78390# m1_14034_78390#
+ m1_34814_78390# m1_57300_78390# m1_59556_78390# m1_28808_78390# m1_5666_78390# m1_28008_78390#
+ pattern_row_small_cs_2_0/m4_47972_4350# m1_59956_78390# m1_12178_78390# m1_38270_78390#
+ m1_40126_78390# m1_10178_78390# m1_24296_78390# m1_7522_78390# m1_52244_78390# m1_55700_78390#
+ m1_53044_78390# m1_36414_78390# m1_8322_78390# m1_14834_78390# m1_20440_78390# m1_34414_78390#
+ m1_10978_78390# m1_26952_78390# m1_56500_78390# m1_39070_78390# pattern_row_small_cs_2_0/m4_26792_3570#
+ m1_28408_78390# pattern_row_small_cs_2_0/m4_38910_4038# m1_25752_78390# m1_45582_78390#
+ m1_51188_78390# pattern_row_small_cs_2_0/m4_20680_3258# m1_29608_78390# m1_57700_78390#
+ m1_35214_78390# pattern_row_small_cs_2_0/m4_17624_3102# m1_9778_78390# m1_7122_78390#
+ pattern_row_small_cs_2_0/m4_51028_4506# m1_41726_78390# m1_4466_78390# pattern_row_small_cs_2_0/m4_41966_4194#
+ m1_21896_78390# m1_52644_78390# m1_29208_78390# m1_53844_78390# m1_6066_78390# m1_49988_78390#
+ m1_34014_78390# m1_60356_78390# pattern_row_small_cs_2_0/m4_5506_2634# pattern_row_small_cs_2_0/m4_2450_2478#
+ m1_43982_78390# m1_7922_78390# m1_8722_78390# m1_53444_78390# pattern_row_small_cs_2_0/m4_8562_2790#
+ m1_25352_78390# m1_22696_78390# m1_15234_78390# m1_20840_78390# m1_43182_78390#
+ m1_27352_78390# m1_55300_78390# pattern_row_small_cs_2_0/m4_32798_3726# m1_4066_78390#
+ m1_11378_78390# m1_39470_78390# m1_49588_78390# m1_26152_78390# m1_23496_78390#
+ m1_51588_78390# pattern_row_small_cs_2_0/pattern_unit_small_row_label_3/m5_70_3052#
+ pattern_row_small_cs_2_0/m4_54084_4662# m1_3666_78390# m1_30008_78390# m1_35614_78390#
+ m1_43582_78390# m1_42126_78390# m1_40926_78390# m1_4866_78390# pattern_row_small_cs_2_0/m4_23736_3414#
+ m1_54244_78390# m1_50388_78390# m1_22296_78390# m1_19640_78390# m1_60756_78390#
+ m1_12834_78390# m1_44382_78390# m1_44782_78390# m1_24952_78390# m1_13634_78390#
+ m1_9122_78390# m1_56900_78390# m1_37070_78390# m1_59156_78390# m1_23096_78390# m1_21240_78390#
+ m1_49188_78390# m1_5266_78390# m1_40526_78390# pattern_row_small_cs_2_0/m4_57140_4818#
+ pattern_row_small_cs_2_0/m4_35854_3882# m1_37870_78390# m1_11778_78390# m1_23896_78390#
+ m1_19240_78390# m1_30408_78390# m1_36014_78390# m1_58356_78390# m1_14434_78390#
+ m1_41326_78390# m1_42526_78390# m1_13234_78390# m1_10578_78390# m1_26552_78390#
+ m1_54644_78390# m1_58756_78390# m1_6722_78390# m1_56100_78390# m1_38670_78390# m1_20040_78390#
+ pattern_row_small_cs_2_0/m4_11618_2946# m1_18840_78390# pattern_row_small_cs_2
.ends

.subckt pattern_array_small_cs_TOP pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_51028_4506#
+ pattern_array_small_cs_0/pattern_row_small_cs_0/m4_5506_2634# pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_11618_2946#
+ pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_41966_4194# pattern_array_small_cs_0/m1_20440_78390#
+ pattern_array_small_cs_0/m1_56500_78390# pattern_array_small_cs_0/m1_25752_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_32798_3726# pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_51028_4506#
+ pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_8562_2790# pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_41966_4194#
+ pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_20680_3258# pattern_array_small_cs_0/pattern_row_small_cs_0/m4_8562_2790#
+ pattern_array_small_cs_0/m1_39470_78390# pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_23736_3414#
+ pattern_array_small_cs_0/pattern_row_small_cs_0/m4_23736_3414# pattern_array_small_cs_0/m1_18840_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_17624_3102# pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_20680_3258#
+ pattern_array_small_cs_0/m1_7122_78390# pattern_array_small_cs_0/m1_13234_78390#
+ pattern_array_small_cs_0/m1_49188_78390# pattern_array_small_cs_0/m1_36414_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_54084_4662# pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_23736_3414#
+ pattern_array_small_cs_0/m1_43982_78390# pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_57140_4818#
+ pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_2450_2478# pattern_array_small_cs_0/m1_53044_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_35854_3882# pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_17624_3102#
+ pattern_array_small_cs_0/m1_22296_78390# pattern_array_small_cs_0/m1_40926_78390#
+ pattern_array_small_cs_0/m1_58356_78390# pattern_array_small_cs_0/m1_8722_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_26792_3570# pattern_array_small_cs_0/m1_14834_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_38910_4038# pattern_array_small_cs_0/m1_54644_78390#
+ pattern_array_small_cs_0/m1_29208_78390# pattern_array_small_cs_0/m1_59956_78390#
+ pattern_array_small_cs_0/m1_23896_78390# pattern_array_small_cs_0/pattern_row_small_cs_0/m4_47972_4350#
+ pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_5506_2634# pattern_array_small_cs_0/m1_55300_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_11618_2946# pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_32798_3726#
+ pattern_array_small_cs_0/m1_45182_78390# pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_47972_4350#
+ pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_51028_4506# pattern_array_small_cs_0/m1_42126_78390#
+ pattern_array_small_cs_0/m1_11378_78390# pattern_array_small_cs_0/m1_5266_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_41966_4194# pattern_array_small_cs_0/m1_56900_78390#
+ pattern_array_small_cs_0/m1_38270_78390# pattern_array_small_cs_0/m1_20840_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_5506_2634# pattern_array_small_cs_0/m1_51188_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_8562_2790# pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_54084_4662#
+ pattern_array_small_cs_0/m1_35214_78390# pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_32798_3726#
+ pattern_array_small_cs_0/m1_60356_78390# pattern_array_small_cs_0/m1_49588_78390#
+ pattern_array_small_cs_0/m1_7522_78390# pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_2450_2478#
+ pattern_array_small_cs_0/m1_13634_78390# pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_54084_4662#
+ pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_8562_2790# pattern_array_small_cs_0/m1_53444_78390#
+ pattern_array_small_cs_0/m1_28008_78390# pattern_array_small_cs_0/m1_22696_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_0/m4_26792_3570# pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_57140_4818#
+ pattern_array_small_cs_0/m1_27352_78390# pattern_array_small_cs_0/m1_58756_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_35854_3882# pattern_array_small_cs_0/pattern_row_small_cs_0/m4_38910_4038#
+ pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_26792_3570# pattern_array_small_cs_0/m1_29608_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_38910_4038# pattern_array_small_cs_0/m1_10178_78390#
+ pattern_array_small_cs_0/m1_4066_78390# pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_11618_2946#
+ pattern_array_small_cs_0/m1_55700_78390# pattern_array_small_cs_0/m1_37070_78390#
+ pattern_array_small_cs_0/m1_45582_78390# pattern_array_small_cs_0/m1_24952_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_20680_3258# pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_47972_4350#
+ pattern_array_small_cs_0/pattern_row_small_cs_0/m4_51028_4506# pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_2450_2478#
+ pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_32798_3726# pattern_array_small_cs_0/m1_42526_78390#
+ pattern_array_small_cs_0/m1_5666_78390# pattern_array_small_cs_0/m1_11778_78390#
+ pattern_array_small_cs_0/m1_34014_78390# pattern_array_small_cs_0/pattern_row_small_cs_0/m4_41966_4194#
+ pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_51028_4506# pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_17624_3102#
+ pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_23736_3414# pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_20680_3258#
+ pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_5506_2634# pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_41966_4194#
+ pattern_array_small_cs_0/m1_38670_78390# pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_17624_3102#
+ pattern_array_small_cs_0/m1_51588_78390# pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_23736_3414#
+ pattern_array_small_cs_0/m1_35614_78390# pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_54084_4662#
+ pattern_array_small_cs_0/m1_30008_78390# pattern_array_small_cs_0/m1_60756_78390#
+ pattern_array_small_cs_0/m1_52244_78390# pattern_array_small_cs_0/m1_26152_78390#
+ pattern_array_small_cs_0/m1_49988_78390# pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_57140_4818#
+ pattern_array_small_cs_0/m1_7922_78390# pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_35854_3882#
+ pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_8562_2790# pattern_array_small_cs_0/m1_53844_78390#
+ pattern_array_small_cs_0/m1_28408_78390# pattern_array_small_cs_0/m1_19240_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_57140_4818# pattern_array_small_cs_0/pattern_row_small_cs_0/m4_2450_2478#
+ pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_35854_3882# pattern_array_small_cs_0/m1_44382_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_26792_3570# pattern_array_small_cs_0/m1_41326_78390#
+ pattern_array_small_cs_0/m1_4466_78390# pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_11618_2946#
+ pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_38910_4038# pattern_array_small_cs_0/m1_10578_78390#
+ pattern_array_small_cs_0/m1_9122_78390# pattern_array_small_cs_0/m1_15234_78390#
+ pattern_array_small_cs_0/m1_37470_78390# pattern_array_small_cs_0/pattern_row_small_cs_0/m4_11618_2946#
+ pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_2450_2478# pattern_array_small_cs_0/m1_9778_78390#
+ pattern_array_small_cs_0/m1_50388_78390# pattern_array_small_cs_0/pattern_row_small_cs_0/m4_32798_3726#
+ pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_47972_4350# pattern_array_small_cs_0/m1_24296_78390#
+ pattern_array_small_cs_0/m1_34414_78390# pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_32798_3726#
+ pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_5506_2634# pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_51028_4506#
+ pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_41966_4194# pattern_array_small_cs_0/pattern_row_small_cs_0/m4_54084_4662#
+ pattern_array_small_cs_0/m1_6722_78390# pattern_array_small_cs_0/m1_12834_78390#
+ pattern_array_small_cs_0/m1_30408_78390# pattern_array_small_cs_0/m1_21896_78390#
+ pattern_array_small_cs_0/m1_21240_78390# pattern_array_small_cs_0/m1_52644_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_54084_4662# pattern_array_small_cs_0/m1_26552_78390#
+ pattern_array_small_cs_0/m1_57300_78390# pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_8562_2790#
+ pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_2450_2478# pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_35854_3882#
+ pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_57140_4818# pattern_array_small_cs_0/m1_43182_78390#
+ pattern_array_small_cs_0/m1_28808_78390# pattern_array_small_cs_0/m1_19640_78390#
+ pattern_array_small_cs_0/m1_40126_78390# pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_20680_3258#
+ pattern_array_small_cs_0/pattern_row_small_cs_0/m4_20680_3258# pattern_array_small_cs_0/m1_44782_78390#
+ pattern_array_small_cs_0/m1_14034_78390# pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_20680_3258#
+ pattern_array_small_cs_0/pattern_row_small_cs_0/m4_17624_3102# pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_17624_3102#
+ pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_23736_3414# pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_11618_2946#
+ pattern_array_small_cs_0/m1_23096_78390# pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_17624_3102#
+ pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_26792_3570# pattern_array_small_cs_0/m1_41726_78390#
+ pattern_array_small_cs_0/m1_59156_78390# pattern_array_small_cs_0/m1_10978_78390#
+ pattern_array_small_cs_0/m1_4866_78390# pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_47972_4350#
+ pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_23736_3414# pattern_array_small_cs_0/m1_37870_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_38910_4038# pattern_array_small_cs_0/m1_50788_78390#
+ pattern_array_small_cs_0/m1_34814_78390# pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_5506_2634#
+ pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_47972_4350# pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_11618_2946#
+ pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_32798_3726# pattern_array_small_cs_0/m1_20040_78390#
+ pattern_array_small_cs_0/m1_56100_78390# pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_51028_4506#
+ pattern_array_small_cs_0/m1_25352_78390# pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_41966_4194#
+ pattern_array_small_cs_0/m1_6066_78390# pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_8562_2790#
+ pattern_array_small_cs_0/m1_12178_78390# pattern_array_small_cs_0/m1_39070_78390#
+ pattern_array_small_cs_0/m1_57700_78390# pattern_array_small_cs_0/pattern_row_small_cs_0/m4_35854_3882#
+ pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_54084_4662# pattern_array_small_cs_0/m1_26952_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_0/m4_57140_4818# pattern_array_small_cs_0/m1_36014_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_57140_4818# pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_35854_3882#
+ pattern_array_small_cs_0/m1_43582_78390# m4_1212_n4# pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_26792_3570#
+ pattern_array_small_cs_0/m1_40526_78390# pattern_array_small_cs_0/m1_3666_78390#
+ pattern_array_small_cs_0/m1_8322_78390# pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_38910_4038#
+ pattern_array_small_cs_0/m1_14434_78390# pattern_array_small_cs_0/m1_54244_78390#
+ pattern_array_small_cs_0/m1_23496_78390# pattern_array_small_cs_0/m1_59556_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_26792_3570# pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_47972_4350#
+ pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_2450_2478# pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_5506_2634#
+ pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_38910_4038#
Xpattern_array_small_cs_0 pattern_array_small_cs_0/m1_26152_78390# pattern_array_small_cs_0/m1_49988_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_5506_2634# pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_32798_3726#
+ pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_11618_2946# pattern_array_small_cs_0/m1_53844_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_2450_2478# pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_51028_4506#
+ pattern_array_small_cs_0/m1_28408_78390# pattern_array_small_cs_0/m1_19240_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_41966_4194# pattern_array_small_cs_0/m1_7122_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_5506_2634# pattern_array_small_cs_0/m1_44382_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_54084_4662# pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_8562_2790#
+ pattern_array_small_cs_0/m1_10578_78390# pattern_array_small_cs_0/m1_41326_78390#
+ pattern_array_small_cs_0/m1_8722_78390# pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_57140_4818#
+ pattern_array_small_cs_0/m1_15234_78390# pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_35854_3882#
+ pattern_array_small_cs_0/m1_37470_78390# pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_26792_3570#
+ pattern_array_small_cs_0/m1_50388_78390# pattern_array_small_cs_0/pattern_row_small_cs_0/m4_23736_3414#
+ pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_20680_3258# pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_38910_4038#
+ pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_23736_3414# pattern_array_small_cs_0/m1_24296_78390#
+ pattern_array_small_cs_0/m1_34414_78390# pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_8562_2790#
+ pattern_array_small_cs_0/pattern_row_small_cs_0/m4_5506_2634# pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_20680_3258#
+ pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_17624_3102# pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_23736_3414#
+ pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_2450_2478# pattern_array_small_cs_0/pattern_row_small_cs_0/m4_26792_3570#
+ pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_17624_3102# pattern_array_small_cs_0/pattern_row_small_cs_0/m4_38910_4038#
+ pattern_array_small_cs_0/m1_12834_78390# pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_32798_3726#
+ pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_47972_4350# pattern_array_small_cs_0/m1_5266_78390#
+ pattern_array_small_cs_0/m1_30408_78390# pattern_array_small_cs_0/m1_52644_78390#
+ pattern_array_small_cs_0/m1_21240_78390# pattern_array_small_cs_0/m1_21896_78390#
+ pattern_array_small_cs_0/m1_57300_78390# pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_51028_4506#
+ pattern_array_small_cs_0/m1_26552_78390# pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_41966_4194#
+ pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_11618_2946# pattern_array_small_cs_0/pattern_row_small_cs_0/m4_8562_2790#
+ pattern_array_small_cs_0/pattern_row_small_cs_0/m4_2450_2478# pattern_array_small_cs_0/m1_43182_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_54084_4662# pattern_array_small_cs_0/pattern_row_small_cs_0/m4_51028_4506#
+ pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_32798_3726# pattern_array_small_cs_0/m1_28808_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_0/m4_41966_4194# pattern_array_small_cs_0/m1_19640_78390#
+ pattern_array_small_cs_0/m1_40126_78390# pattern_array_small_cs_0/m1_7522_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_5506_2634# pattern_array_small_cs_0/m1_14034_78390#
+ pattern_array_small_cs_0/m1_44782_78390# pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_54084_4662#
+ pattern_array_small_cs_0/m1_10978_78390# pattern_array_small_cs_0/m1_23096_78390#
+ pattern_array_small_cs_0/m1_41726_78390# pattern_array_small_cs_0/m1_59156_78390#
+ pattern_array_small_cs_0/m1_37870_78390# pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_57140_4818#
+ pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_35854_3882# pattern_array_small_cs_0/m1_50788_78390#
+ m4_1212_n4# pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_8562_2790# pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_26792_3570#
+ pattern_array_small_cs_0/m1_34814_78390# pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_2450_2478#
+ pattern_array_small_cs_0/m1_4066_78390# pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_38910_4038#
+ pattern_array_small_cs_0/m1_20040_78390# pattern_array_small_cs_0/m1_25352_78390#
+ pattern_array_small_cs_0/m1_56100_78390# pattern_array_small_cs_0/m1_5666_78390#
+ pattern_array_small_cs_0/m1_12178_78390# pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_32798_3726#
+ pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_47972_4350# pattern_array_small_cs_0/m1_26952_78390#
+ pattern_array_small_cs_0/m1_39070_78390# pattern_array_small_cs_0/m1_57700_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_11618_2946# pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_51028_4506#
+ pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_41966_4194# pattern_array_small_cs_0/m1_36014_78390#
+ pattern_array_small_cs_0/m1_43582_78390# pattern_array_small_cs_0/pattern_row_small_cs_0/m4_32798_3726#
+ pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_5506_2634# pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_54084_4662#
+ pattern_array_small_cs_0/m1_40526_78390# pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_20680_3258#
+ pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_2450_2478# pattern_array_small_cs_0/m1_7922_78390#
+ pattern_array_small_cs_0/m1_14434_78390# pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_57140_4818#
+ pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_20680_3258# pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_17624_3102#
+ pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_35854_3882# pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_23736_3414#
+ pattern_array_small_cs_0/m1_54244_78390# pattern_array_small_cs_0/pattern_row_small_cs_0/m4_54084_4662#
+ pattern_array_small_cs_0/m1_23496_78390# pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_17624_3102#
+ pattern_array_small_cs_0/m1_59556_78390# pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_23736_3414#
+ pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_8562_2790# pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_57140_4818#
+ pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_35854_3882# pattern_array_small_cs_0/m1_4466_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_26792_3570# pattern_array_small_cs_0/m1_9122_78390#
+ pattern_array_small_cs_0/m1_20440_78390# pattern_array_small_cs_0/m1_9778_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_38910_4038# pattern_array_small_cs_0/m1_56500_78390#
+ m4_1212_n4# pattern_array_small_cs_0/m1_25752_78390# pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_11618_2946#
+ pattern_array_small_cs_0/m1_18840_78390# pattern_array_small_cs_0/m1_39470_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_32798_3726# pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_47972_4350#
+ pattern_array_small_cs_0/m1_6722_78390# m4_1212_n4# pattern_array_small_cs_0/m1_13234_78390#
+ pattern_array_small_cs_0/m1_36414_78390# pattern_array_small_cs_0/m1_43982_78390#
+ pattern_array_small_cs_0/m1_49188_78390# pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_51028_4506#
+ pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_5506_2634# pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_2450_2478#
+ pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_41966_4194# pattern_array_small_cs_0/m1_22296_78390#
+ pattern_array_small_cs_0/m1_40926_78390# pattern_array_small_cs_0/m1_53044_78390#
+ pattern_array_small_cs_0/m1_58356_78390# pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_54084_4662#
+ pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_11618_2946# pattern_array_small_cs_0/m1_14834_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_57140_4818# pattern_array_small_cs_0/m1_23896_78390#
+ pattern_array_small_cs_0/m1_54644_78390# m4_1212_n4# pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_35854_3882#
+ pattern_array_small_cs_0/m1_29208_78390# pattern_array_small_cs_0/m1_59956_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_8562_2790# pattern_array_small_cs_0/pattern_row_small_cs_0/m4_57140_4818#
+ pattern_array_small_cs_0/m1_45182_78390# pattern_array_small_cs_0/m1_55300_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_0/m4_35854_3882# pattern_array_small_cs_0/pattern_row_small_cs_0/m4_11618_2946#
+ pattern_array_small_cs_0/m1_42126_78390# pattern_array_small_cs_0/m1_4866_78390#
+ pattern_array_small_cs_0/m1_11378_78390# pattern_array_small_cs_0/m1_20840_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_2450_2478# pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_26792_3570#
+ pattern_array_small_cs_0/m1_38270_78390# pattern_array_small_cs_0/m1_56900_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_47972_4350# pattern_array_small_cs_0/m1_51188_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_38910_4038# pattern_array_small_cs_0/pattern_row_small_cs_0/m4_20680_3258#
+ pattern_array_small_cs_0/m1_35214_78390# m4_1212_n4# pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_20680_3258#
+ pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_20680_3258# pattern_array_small_cs_0/pattern_row_small_cs_0/m4_17624_3102#
+ pattern_array_small_cs_0/m1_60356_78390# pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_17624_3102#
+ pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_23736_3414# pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_47972_4350#
+ pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_32798_3726# pattern_array_small_cs_0/m1_13634_78390#
+ pattern_array_small_cs_0/m1_49588_78390# pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_17624_3102#
+ pattern_array_small_cs_0/m1_6066_78390# pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_5506_2634#
+ pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_23736_3414# pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_51028_4506#
+ pattern_array_small_cs_0/m1_53444_78390# pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_41966_4194#
+ pattern_array_small_cs_0/pattern_row_small_cs_2_0/m4_11618_2946# pattern_array_small_cs_0/m1_22696_78390#
+ pattern_array_small_cs_0/m1_28008_78390# pattern_array_small_cs_0/m1_58756_78390#
+ pattern_array_small_cs_0/m1_27352_78390# pattern_array_small_cs_0/pattern_row_small_cs_3_0/m4_54084_4662#
+ pattern_array_small_cs_0/m1_29608_78390# pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_57140_4818#
+ pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_8562_2790# pattern_array_small_cs_0/m1_3666_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_4_0/m4_35854_3882# pattern_array_small_cs_0/m1_10178_78390#
+ pattern_array_small_cs_0/m1_8322_78390# pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_26792_3570#
+ pattern_array_small_cs_0/m1_37070_78390# pattern_array_small_cs_0/m1_45582_78390#
+ pattern_array_small_cs_0/m1_55700_78390# pattern_array_small_cs_0/m1_24952_78390#
+ pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_38910_4038# pattern_array_small_cs_0/m1_34014_78390#
+ pattern_array_small_cs_0/m1_42526_78390# pattern_array_small_cs_0/m1_11778_78390#
+ pattern_array_small_cs_0/m1_38670_78390# pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_26792_3570#
+ pattern_array_small_cs_0/m1_51588_78390# m4_1212_n4# pattern_array_small_cs_0/pattern_row_small_cs_5_0/m4_47972_4350#
+ pattern_array_small_cs_0/m1_35614_78390# pattern_array_small_cs_0/pattern_row_small_cs_1_0/m4_38910_4038#
+ pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_51028_4506# pattern_array_small_cs_0/m1_30008_78390#
+ pattern_array_small_cs_0/m1_52244_78390# pattern_array_small_cs_0/m1_60756_78390#
+ m4_1212_n4# pattern_array_small_cs_0/pattern_row_small_cs_6_0/m4_41966_4194# pattern_array_small_cs_0/pattern_row_small_cs_0/m4_47972_4350#
+ pattern_array_small_cs
.ends

.subckt bp_lines_horiz_main bondpad_lines_horiz_0[6]/m2_n36_9584# bondpad_lines_horiz_0[4]/m2_n36_6384#
+ bondpad_lines_horiz_0[2]/m2_n36_3184# bondpad_lines_horiz_0[6]/m2_n36_n16# bondpad_lines_horiz_0[1]/m2_n36_n16#
+ bondpad_lines_horiz_0[2]/m2_n36_11184# bondpad_lines_horiz_0[6]/m2_n36_7984# bondpad_lines_horiz_0[2]/m2_n36_1584#
+ bondpad_lines_horiz_0[4]/m2_n36_4784# bondpad_lines_horiz_0[6]/m2_n36_11184# bondpad_lines_horiz_0[1]/m2_n36_9584#
+ bondpad_lines_horiz_0[5]/m2_n36_3184# bondpad_lines_horiz_0[5]/m2_n36_1584# bondpad_lines_horiz_0[1]/m2_n36_7984#
+ bondpad_lines_horiz_0[5]/m2_n36_n16# bondpad_lines_horiz_0[0]/m2_n36_n16# bondpad_lines_horiz_0[4]/m2_n36_7984#
+ bondpad_lines_horiz_0[2]/m2_n36_6384# bondpad_lines_horiz_0[4]/m2_n36_9584# bondpad_lines_horiz_0[2]/m2_n36_4784#
+ bondpad_lines_horiz_0[3]/m2_n36_11184# bondpad_lines_horiz_0[0]/m2_n36_3184# bondpad_lines_horiz_0[0]/m2_n36_1584#
+ bondpad_lines_horiz_0[5]/m2_n36_6384# bondpad_lines_horiz_0[3]/m2_n36_3184# bondpad_lines_horiz_0[3]/m2_n36_1584#
+ bondpad_lines_horiz_0[5]/m2_n36_4784# bondpad_lines_horiz_0[4]/m2_n36_n16# bondpad_lines_horiz_0[0]/m2_n36_11184#
+ bondpad_lines_horiz_0[2]/m2_n36_9584# bondpad_lines_horiz_0[6]/m2_n36_3184# bondpad_lines_horiz_0[4]/m2_n36_11184#
+ bondpad_lines_horiz_0[0]/m2_n36_6384# bondpad_lines_horiz_0[2]/m2_n36_7984# bondpad_lines_horiz_0[0]/m2_n36_4784#
+ bondpad_lines_horiz_0[6]/m2_n36_1584# bondpad_lines_horiz_0[5]/m2_n36_9584# bondpad_lines_horiz_0[3]/m2_n36_n16#
+ bondpad_lines_horiz_0[3]/m2_n36_6384# bondpad_lines_horiz_0[5]/m2_n36_7984# bondpad_lines_horiz_0[1]/m2_n36_3184#
+ bondpad_lines_horiz_0[3]/m2_n36_4784# bondpad_lines_horiz_0[1]/m2_n36_1584# bondpad_lines_horiz_0[6]/m2_n36_6384#
+ bondpad_lines_horiz_0[1]/m2_n36_11184# bondpad_lines_horiz_0[6]/m2_n36_4784# bondpad_lines_horiz_0[0]/m2_n36_9584#
+ bondpad_lines_horiz_0[4]/m2_n36_3184# bondpad_lines_horiz_0[4]/m2_n36_1584# bondpad_lines_horiz_0[0]/m2_n36_7984#
+ bondpad_lines_horiz_0[5]/m2_n36_11184# bondpad_lines_horiz_0[2]/m2_n36_n16# bondpad_lines_horiz_0[3]/m2_n36_9584#
+ bondpad_lines_horiz_0[1]/m2_n36_6384# bondpad_lines_horiz_0[3]/m2_n36_7984# bondpad_lines_horiz_0[1]/m2_n36_4784#
.ends

.subckt bp_lines_horiz_main_both bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_6384#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_n16# bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_3184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_4784# bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_11184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_1584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_9584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_6384# bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_7984#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_3184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_4784#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_3184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_1584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_9584# bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_6384#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_n16# bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_1584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_7984# bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_n16#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_11184# bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_4784#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_6384# bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_n16#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_3184# bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_n16#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_4784# bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_11184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_11184# bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_9584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_1584# bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_6384#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_7984# bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_3184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_4784# bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_11184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_1584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_3184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_9584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_6384#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_1584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_7984#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_n16# bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_6384#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_n16# bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_4784#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_9584# bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_3184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_4784# bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_n16#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_1584# bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_n16#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_7984# bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_9584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_11184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_6384#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_7984# bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_3184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_4784# bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_11184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_1584# bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_9584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_6384# bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_7984#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_4784# bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_n16#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_6384# bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_3184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_9584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_4784#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_n16# bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_9584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_1584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_7984#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_6384# bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_11184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_7984# bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_3184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_4784# bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_1584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_9584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_11184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_11184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_6384#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_7984# bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_4784#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_n16# bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_3184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_9584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_11184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_1584# bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_7984#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_n16# bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_9584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_6384# bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_7984#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_3184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_4784#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_9584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_1584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_6384# bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_7984#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_3184# bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_11184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_4784# bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_1584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_3184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_9584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_n16# bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_11184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_11184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_1584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_7984#
Xbp_lines_horiz_main_0 bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_9584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_6384# bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_3184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_n16# bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_n16#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_11184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_7984#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_1584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_4784#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_11184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_9584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_3184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_1584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_7984# bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_n16#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_n16# bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_7984#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_6384# bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_9584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_4784# bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_11184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_3184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_1584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_6384# bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_3184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_1584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_4784#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_n16# bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_11184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_9584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_3184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_11184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_6384#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_7984# bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_4784#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_1584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_9584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_n16# bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_6384#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_7984# bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_3184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_4784# bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_1584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_6384# bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_11184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_4784# bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_9584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_3184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_1584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_7984# bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_11184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_n16# bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_9584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_6384# bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_7984#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_4784# bp_lines_horiz_main
Xbp_lines_horiz_main_1 bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_9584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_6384# bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_3184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_n16# bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_n16#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_11184# bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_7984#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_1584# bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_4784#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_11184# bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_9584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_3184# bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_1584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_7984# bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_n16#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_n16# bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_7984#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_6384# bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_9584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_4784# bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_11184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_3184# bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_1584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_6384# bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_3184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_1584# bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_4784#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_n16# bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_11184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_9584# bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_3184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_11184# bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_6384#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_7984# bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_4784#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_1584# bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_9584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_n16# bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_6384#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_7984# bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_3184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_4784# bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_1584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_6384# bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_11184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_4784# bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_9584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_3184# bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_1584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_7984# bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_11184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_n16# bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_9584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_6384# bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_7984#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_4784# bp_lines_horiz_main
.ends

.subckt bondpad_array_ds_6 pad4diode_0[2|5]/pad3_0/m4_n10636_n5828# pad4diode_0[3|1]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[0|7]/pad3_0/m4_n10636_n5828# pad4diode_1[1|3]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[0|3]/pad3_0/m4_n10636_n5828# pad4diode_1[5|4]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[6|6]/pad3_0/m4_n10636_n5828# pad4diode_1[6|0]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[5|0]/pad3_0/m4_n10636_n5828# pad4diode_0[4|4]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[3|2]/pad3_0/m4_n10636_n5828# pad4diode_1[2|6]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[1|6]/pad3_0/m4_n10636_n5828# pad4diode_0[2|2]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[0|4]/pad3_0/m4_n10636_n5828# pad4diode_1[1|0]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[6|7]/pad3_0/m4_n10636_n5828# pad4diode_0[0|0]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[5|7]/pad3_0/m4_n10636_n5828# pad4diode_0[6|3]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[5|1]/pad3_0/m4_n10636_n5828# pad4diode_1[4|5]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[3|5]/pad3_0/m4_n10636_n5828# pad4diode_0[4|1]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[1|7]/pad3_0/m4_n10636_n5828# pad4diode_1[2|3]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[0|7]/pad3_0/m4_n10636_n5828# pad4diode_0[1|3]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[0|1]/pad3_0/m4_n10636_n5828# pad4diode_1[6|4]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[5|4]/pad3_0/m4_n10636_n5828# pad4diode_0[6|0]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[4|2]/pad3_0/m4_n10636_n5828# pad4diode_1[3|6]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[2|6]/pad3_0/m4_n10636_n5828# pad4diode_0[3|2]/pad3_0/m4_n10636_n5828#
+ VSUBS pad4diode_1[1|4]/pad3_0/m4_n10636_n5828# pad4diode_1[2|0]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[0|4]/pad3_0/m4_n10636_n5828# pad4diode_0[1|0]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[6|1]/pad3_0/m4_n10636_n5828# pad4diode_1[5|5]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[6|7]/pad3_0/m4_n10636_n5828# pad4diode_0[5|1]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[4|5]/pad3_0/m4_n10636_n5828# pad4diode_1[2|7]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[3|3]/pad3_0/m4_n10636_n5828# pad4diode_0[1|7]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[2|3]/pad3_0/m4_n10636_n5828# pad4diode_1[0|5]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[1|1]/pad3_0/m4_n10636_n5828# pad4diode_0[0|1]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[6|4]/pad3_0/m4_n10636_n5828# pad4diode_1[5|2]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[4|6]/pad3_0/m4_n10636_n5828# pad4diode_0[4|2]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[3|6]/pad3_0/m4_n10636_n5828# pad4diode_1[3|0]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[2|4]/pad3_0/m4_n10636_n5828# pad4diode_0[1|4]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[2|0]/pad3_0/m4_n10636_n5828# pad4diode_1[0|2]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[6|5]/pad3_0/m4_n10636_n5828# pad4diode_0[5|5]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[6|1]/pad3_0/m4_n10636_n5828# pad4diode_1[4|3]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[3|7]/pad3_0/m4_n10636_n5828# pad4diode_0[3|3]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[2|7]/pad3_0/m4_n10636_n5828# pad4diode_1[1|5]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[2|1]/pad3_0/m4_n10636_n5828# pad4diode_0[1|1]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[0|5]/pad3_0/m4_n10636_n5828# pad4diode_1[6|2]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[5|6]/pad3_0/m4_n10636_n5828# pad4diode_0[4|6]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[5|2]/pad3_0/m4_n10636_n5828# pad4diode_1[4|0]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[3|4]/pad3_0/m4_n10636_n5828# pad4diode_0[3|0]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[2|4]/pad3_0/m4_n10636_n5828# pad4diode_1[0|6]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[1|2]/pad3_0/m4_n10636_n5828# pad4diode_0[0|2]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[6|5]/pad3_0/m4_n10636_n5828# pad4diode_1[4|7]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[5|3]/pad3_0/m4_n10636_n5828# pad4diode_0[3|7]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[4|3]/pad3_0/m4_n10636_n5828# pad4diode_1[2|5]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[3|1]/pad3_0/m4_n10636_n5828# pad4diode_0[1|5]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[2|1]/pad3_0/m4_n10636_n5828# pad4diode_1[0|3]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[6|6]/pad3_0/m4_n10636_n5828# pad4diode_0[5|6]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[6|2]/pad3_0/m4_n10636_n5828# pad4diode_1[4|4]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[5|0]/pad3_0/m4_n10636_n5828# pad4diode_0[4|0]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[3|4]/pad3_0/m4_n10636_n5828# pad4diode_1[2|2]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[1|6]/pad3_0/m4_n10636_n5828# pad4diode_0[0|6]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[1|2]/pad3_0/m4_n10636_n5828# pad4diode_1[0|0]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[5|7]/pad3_0/m4_n10636_n5828# pad4diode_1[6|3]/pad3_0/m4_n10636_n5828#
+ pad4diode_0[5|3]/pad3_0/m4_n10636_n5828# pad4diode_0[4|7]/pad3_0/m4_n10636_n5828#
+ pad4diode_1[4|1]/pad3_0/m4_n10636_n5828# pad4diode_1[3|5]/pad3_0/m4_n10636_n5828#
Xpad4diode_0[0|0] pad4diode_0[0|0]/pad3_0/m4_n10636_n5828# pad4diode_0[0|0]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[1|0] pad4diode_0[1|0]/pad3_0/m4_n10636_n5828# pad4diode_0[1|0]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[2|0] pad4diode_0[2|0]/pad3_0/m4_n10636_n5828# pad4diode_0[2|0]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[3|0] pad4diode_0[3|0]/pad3_0/m4_n10636_n5828# pad4diode_0[3|0]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[4|0] pad4diode_0[4|0]/pad3_0/m4_n10636_n5828# pad4diode_0[4|0]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[5|0] pad4diode_0[5|0]/pad3_0/m4_n10636_n5828# pad4diode_0[5|0]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[6|0] pad4diode_0[6|0]/pad3_0/m4_n10636_n5828# pad4diode_0[6|0]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[0|1] pad4diode_0[0|1]/pad3_0/m4_n10636_n5828# pad4diode_0[0|1]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[1|1] pad4diode_0[1|1]/pad3_0/m4_n10636_n5828# pad4diode_0[1|1]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[2|1] pad4diode_0[2|1]/pad3_0/m4_n10636_n5828# pad4diode_0[2|1]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[3|1] pad4diode_0[3|1]/pad3_0/m4_n10636_n5828# pad4diode_0[3|1]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[4|1] pad4diode_0[4|1]/pad3_0/m4_n10636_n5828# pad4diode_0[4|1]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[5|1] pad4diode_0[5|1]/pad3_0/m4_n10636_n5828# pad4diode_0[5|1]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[6|1] pad4diode_0[6|1]/pad3_0/m4_n10636_n5828# pad4diode_0[6|1]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[0|2] pad4diode_0[0|2]/pad3_0/m4_n10636_n5828# pad4diode_0[0|2]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[1|2] pad4diode_0[1|2]/pad3_0/m4_n10636_n5828# pad4diode_0[1|2]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[2|2] pad4diode_0[2|2]/pad3_0/m4_n10636_n5828# pad4diode_0[2|2]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[3|2] pad4diode_0[3|2]/pad3_0/m4_n10636_n5828# pad4diode_0[3|2]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[4|2] pad4diode_0[4|2]/pad3_0/m4_n10636_n5828# pad4diode_0[4|2]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[5|2] pad4diode_0[5|2]/pad3_0/m4_n10636_n5828# pad4diode_0[5|2]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[6|2] pad4diode_0[6|2]/pad3_0/m4_n10636_n5828# pad4diode_0[6|2]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[0|3] pad4diode_0[0|3]/pad3_0/m4_n10636_n5828# pad4diode_0[0|3]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[1|3] pad4diode_0[1|3]/pad3_0/m4_n10636_n5828# pad4diode_0[1|3]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[2|3] pad4diode_0[2|3]/pad3_0/m4_n10636_n5828# pad4diode_0[2|3]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[3|3] pad4diode_0[3|3]/pad3_0/m4_n10636_n5828# pad4diode_0[3|3]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[4|3] pad4diode_0[4|3]/pad3_0/m4_n10636_n5828# pad4diode_0[4|3]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[5|3] pad4diode_0[5|3]/pad3_0/m4_n10636_n5828# pad4diode_0[5|3]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[6|3] pad4diode_0[6|3]/pad3_0/m4_n10636_n5828# pad4diode_0[6|3]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[0|4] pad4diode_0[0|4]/pad3_0/m4_n10636_n5828# pad4diode_0[0|4]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[1|4] pad4diode_0[1|4]/pad3_0/m4_n10636_n5828# pad4diode_0[1|4]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[2|4] pad4diode_0[2|4]/pad3_0/m4_n10636_n5828# pad4diode_0[2|4]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[3|4] pad4diode_0[3|4]/pad3_0/m4_n10636_n5828# pad4diode_0[3|4]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[4|4] pad4diode_0[4|4]/pad3_0/m4_n10636_n5828# pad4diode_0[4|4]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[5|4] pad4diode_0[5|4]/pad3_0/m4_n10636_n5828# pad4diode_0[5|4]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[6|4] pad4diode_0[6|4]/pad3_0/m4_n10636_n5828# pad4diode_0[6|4]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[0|5] pad4diode_0[0|5]/pad3_0/m4_n10636_n5828# pad4diode_0[0|5]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[1|5] pad4diode_0[1|5]/pad3_0/m4_n10636_n5828# pad4diode_0[1|5]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[2|5] pad4diode_0[2|5]/pad3_0/m4_n10636_n5828# pad4diode_0[2|5]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[3|5] pad4diode_0[3|5]/pad3_0/m4_n10636_n5828# pad4diode_0[3|5]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[4|5] pad4diode_0[4|5]/pad3_0/m4_n10636_n5828# pad4diode_0[4|5]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[5|5] pad4diode_0[5|5]/pad3_0/m4_n10636_n5828# pad4diode_0[5|5]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[6|5] pad4diode_0[6|5]/pad3_0/m4_n10636_n5828# pad4diode_0[6|5]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[0|6] pad4diode_0[0|6]/pad3_0/m4_n10636_n5828# pad4diode_0[0|6]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[1|6] pad4diode_0[1|6]/pad3_0/m4_n10636_n5828# pad4diode_0[1|6]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[2|6] pad4diode_0[2|6]/pad3_0/m4_n10636_n5828# pad4diode_0[2|6]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[3|6] pad4diode_0[3|6]/pad3_0/m4_n10636_n5828# pad4diode_0[3|6]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[4|6] pad4diode_0[4|6]/pad3_0/m4_n10636_n5828# pad4diode_0[4|6]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[5|6] pad4diode_0[5|6]/pad3_0/m4_n10636_n5828# pad4diode_0[5|6]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[6|6] pad4diode_0[6|6]/pad3_0/m4_n10636_n5828# pad4diode_0[6|6]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[0|7] pad4diode_0[0|7]/pad3_0/m4_n10636_n5828# pad4diode_0[0|7]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[1|7] pad4diode_0[1|7]/pad3_0/m4_n10636_n5828# pad4diode_0[1|7]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[2|7] pad4diode_0[2|7]/pad3_0/m4_n10636_n5828# pad4diode_0[2|7]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[3|7] pad4diode_0[3|7]/pad3_0/m4_n10636_n5828# pad4diode_0[3|7]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[4|7] pad4diode_0[4|7]/pad3_0/m4_n10636_n5828# pad4diode_0[4|7]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[5|7] pad4diode_0[5|7]/pad3_0/m4_n10636_n5828# pad4diode_0[5|7]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_0[6|7] pad4diode_0[6|7]/pad3_0/m4_n10636_n5828# pad4diode_0[6|7]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[0|0] pad4diode_1[0|0]/pad3_0/m4_n10636_n5828# pad4diode_1[0|0]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[1|0] pad4diode_1[1|0]/pad3_0/m4_n10636_n5828# pad4diode_1[1|0]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[2|0] pad4diode_1[2|0]/pad3_0/m4_n10636_n5828# pad4diode_1[2|0]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[3|0] pad4diode_1[3|0]/pad3_0/m4_n10636_n5828# pad4diode_1[3|0]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[4|0] pad4diode_1[4|0]/pad3_0/m4_n10636_n5828# pad4diode_1[4|0]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[5|0] pad4diode_1[5|0]/pad3_0/m4_n10636_n5828# pad4diode_1[5|0]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[6|0] pad4diode_1[6|0]/pad3_0/m4_n10636_n5828# pad4diode_1[6|0]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[0|1] pad4diode_1[0|1]/pad3_0/m4_n10636_n5828# pad4diode_1[0|1]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[1|1] pad4diode_1[1|1]/pad3_0/m4_n10636_n5828# pad4diode_1[1|1]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[2|1] pad4diode_1[2|1]/pad3_0/m4_n10636_n5828# pad4diode_1[2|1]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[3|1] pad4diode_1[3|1]/pad3_0/m4_n10636_n5828# pad4diode_1[3|1]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[4|1] pad4diode_1[4|1]/pad3_0/m4_n10636_n5828# pad4diode_1[4|1]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[5|1] pad4diode_1[5|1]/pad3_0/m4_n10636_n5828# pad4diode_1[5|1]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[6|1] pad4diode_1[6|1]/pad3_0/m4_n10636_n5828# pad4diode_1[6|1]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[0|2] pad4diode_1[0|2]/pad3_0/m4_n10636_n5828# pad4diode_1[0|2]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[1|2] pad4diode_1[1|2]/pad3_0/m4_n10636_n5828# pad4diode_1[1|2]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[2|2] pad4diode_1[2|2]/pad3_0/m4_n10636_n5828# pad4diode_1[2|2]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[3|2] pad4diode_1[3|2]/pad3_0/m4_n10636_n5828# pad4diode_1[3|2]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[4|2] pad4diode_1[4|2]/pad3_0/m4_n10636_n5828# pad4diode_1[4|2]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[5|2] pad4diode_1[5|2]/pad3_0/m4_n10636_n5828# pad4diode_1[5|2]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[6|2] pad4diode_1[6|2]/pad3_0/m4_n10636_n5828# pad4diode_1[6|2]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[0|3] pad4diode_1[0|3]/pad3_0/m4_n10636_n5828# pad4diode_1[0|3]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[1|3] pad4diode_1[1|3]/pad3_0/m4_n10636_n5828# pad4diode_1[1|3]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[2|3] pad4diode_1[2|3]/pad3_0/m4_n10636_n5828# pad4diode_1[2|3]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[3|3] pad4diode_1[3|3]/pad3_0/m4_n10636_n5828# pad4diode_1[3|3]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[4|3] pad4diode_1[4|3]/pad3_0/m4_n10636_n5828# pad4diode_1[4|3]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[5|3] pad4diode_1[5|3]/pad3_0/m4_n10636_n5828# pad4diode_1[5|3]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[6|3] pad4diode_1[6|3]/pad3_0/m4_n10636_n5828# pad4diode_1[6|3]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[0|4] pad4diode_1[0|4]/pad3_0/m4_n10636_n5828# pad4diode_1[0|4]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[1|4] pad4diode_1[1|4]/pad3_0/m4_n10636_n5828# pad4diode_1[1|4]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[2|4] pad4diode_1[2|4]/pad3_0/m4_n10636_n5828# pad4diode_1[2|4]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[3|4] pad4diode_1[3|4]/pad3_0/m4_n10636_n5828# pad4diode_1[3|4]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[4|4] pad4diode_1[4|4]/pad3_0/m4_n10636_n5828# pad4diode_1[4|4]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[5|4] pad4diode_1[5|4]/pad3_0/m4_n10636_n5828# pad4diode_1[5|4]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[6|4] pad4diode_1[6|4]/pad3_0/m4_n10636_n5828# pad4diode_1[6|4]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[0|5] pad4diode_1[0|5]/pad3_0/m4_n10636_n5828# pad4diode_1[0|5]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[1|5] pad4diode_1[1|5]/pad3_0/m4_n10636_n5828# pad4diode_1[1|5]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[2|5] pad4diode_1[2|5]/pad3_0/m4_n10636_n5828# pad4diode_1[2|5]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[3|5] pad4diode_1[3|5]/pad3_0/m4_n10636_n5828# pad4diode_1[3|5]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[4|5] pad4diode_1[4|5]/pad3_0/m4_n10636_n5828# pad4diode_1[4|5]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[5|5] pad4diode_1[5|5]/pad3_0/m4_n10636_n5828# pad4diode_1[5|5]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[6|5] pad4diode_1[6|5]/pad3_0/m4_n10636_n5828# pad4diode_1[6|5]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[0|6] pad4diode_1[0|6]/pad3_0/m4_n10636_n5828# pad4diode_1[0|6]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[1|6] pad4diode_1[1|6]/pad3_0/m4_n10636_n5828# pad4diode_1[1|6]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[2|6] pad4diode_1[2|6]/pad3_0/m4_n10636_n5828# pad4diode_1[2|6]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[3|6] pad4diode_1[3|6]/pad3_0/m4_n10636_n5828# pad4diode_1[3|6]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[4|6] pad4diode_1[4|6]/pad3_0/m4_n10636_n5828# pad4diode_1[4|6]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[5|6] pad4diode_1[5|6]/pad3_0/m4_n10636_n5828# pad4diode_1[5|6]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[6|6] pad4diode_1[6|6]/pad3_0/m4_n10636_n5828# pad4diode_1[6|6]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[0|7] pad4diode_1[0|7]/pad3_0/m4_n10636_n5828# pad4diode_1[0|7]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[1|7] pad4diode_1[1|7]/pad3_0/m4_n10636_n5828# pad4diode_1[1|7]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[2|7] pad4diode_1[2|7]/pad3_0/m4_n10636_n5828# pad4diode_1[2|7]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[3|7] pad4diode_1[3|7]/pad3_0/m4_n10636_n5828# pad4diode_1[3|7]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[4|7] pad4diode_1[4|7]/pad3_0/m4_n10636_n5828# pad4diode_1[4|7]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[5|7] pad4diode_1[5|7]/pad3_0/m4_n10636_n5828# pad4diode_1[5|7]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
Xpad4diode_1[6|7] pad4diode_1[6|7]/pad3_0/m4_n10636_n5828# pad4diode_1[6|7]/pad3_0/m5_n10636_n5828#
+ VSUBS pad4diode
.ends

.subckt bondpad_array_ds_6_top bondpad_array_ds_6_0/pad4diode_1[2|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[4|6]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[0|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[3|6]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[1|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[3|5]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[3|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[4|7]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[1|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[1|5]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[5|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[3|7]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[1|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[5|2]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[6|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[4|4]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[6|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[2|2]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[4|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[2|1]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[2|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[5|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[4|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[2|2]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[6|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[4|4]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[2|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[1|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[1|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[6|6]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[5|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[1|6]/pad3_0/m4_n10636_n5828# VSUBS bondpad_array_ds_6_0/pad4diode_1[4|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[5|1]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[1|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[5|7]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[1|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[3|5]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[1|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[3|6]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[4|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[2|4]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[4|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[0|2]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[2|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[6|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[0|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[1|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[0|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[4|1]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[4|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[6|3]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[0|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[0|7]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[4|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[5|7]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[6|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[5|4]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[2|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[0|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[3|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[5|3]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[1|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[3|1]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[3|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[6|7]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[1|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[5|5]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[3|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[5|6]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[5|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[6|2]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[2|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[0|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[0|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[6|1]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[2|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[1|7]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[0|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[6|7]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[0|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[2|5]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[6|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[0|4]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[3|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[2|6]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[6|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[5|6]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[3|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[5|5]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[1|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[3|7]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[3|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[1|1]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[3|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[5|3]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[4|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[3|2]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[5|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[2|7]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[6|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[4|2]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[6|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[0|6]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[4|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[0|1]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[0|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[6|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[2|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[0|2]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[4|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[2|4]/pad3_0/m4_n10636_n5828#
Xbp_lines_horiz_main_both_0 bondpad_array_ds_6_0/pad4diode_1[1|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[4|7]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[3|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[1|4]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[5|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[3|6]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[4|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[2|4]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[4|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[0|2]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[2|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[0|5]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[0|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[4|1]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[6|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[6|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[0|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[4|2]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[1|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[4|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[6|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[5|4]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[0|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[3|2]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[5|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[5|3]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[2|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[0|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[1|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[3|1]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[3|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[1|2]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[5|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[3|4]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[6|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[5|6]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[6|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[2|6]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[0|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[6|1]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[2|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[5|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[0|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[0|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[0|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[6|1]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[2|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[0|4]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[1|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[2|6]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[6|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[6|2]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[5|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[3|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[3|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[5|5]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[1|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[3|3]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[3|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[1|1]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[3|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[5|3]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[3|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[5|4]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[4|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[6|4]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[4|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[0|6]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[6|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[2|7]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[0|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[4|1]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[0|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[2|3]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[6|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[0|2]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[4|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[2|4]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[4|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[3|6]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[0|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[2|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[1|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[3|5]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[1|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[3|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[1|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[5|1]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[4|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[1|6]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[5|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[3|7]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[6|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[4|4]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[6|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[2|2]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[4|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[2|1]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[2|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[4|3]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[2|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[6|5]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[5|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[4|4]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[6|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[5|2]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[1|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[2|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[1|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[1|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[5|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[1|5]/pad3_0/m4_n10636_n5828# bp_lines_horiz_main_both
Xbondpad_array_ds_6_0 bondpad_array_ds_6_0/pad4diode_0[2|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[3|1]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[0|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[1|3]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[0|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[5|4]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[6|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[6|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[5|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[4|4]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[3|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[2|6]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[1|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[2|2]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[0|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[1|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[6|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[0|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[5|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[6|3]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[5|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[4|5]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[3|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[4|1]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[1|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[2|3]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[0|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[1|3]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[0|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[6|4]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[5|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[6|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[4|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[3|6]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[2|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[3|2]/pad3_0/m4_n10636_n5828# VSUBS bondpad_array_ds_6_0/pad4diode_1[1|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[2|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[0|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[1|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[6|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[5|5]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[6|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[5|1]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[4|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[2|7]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[3|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[1|7]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[2|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[0|5]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[1|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[0|1]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[6|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[5|2]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[4|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[4|2]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[3|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[3|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[2|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[1|4]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[2|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[0|2]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[6|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[5|5]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[6|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[4|3]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[3|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[3|3]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[2|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[1|5]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[2|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[1|1]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[0|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[6|2]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[5|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[4|6]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[5|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[4|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[3|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[3|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[2|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[0|6]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[1|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[0|2]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[6|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[4|7]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[5|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[3|7]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[4|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[2|5]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[3|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[1|5]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[2|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[0|3]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[6|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[5|6]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[6|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[4|4]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[5|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[4|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[3|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[2|2]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[1|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[0|6]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[1|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[0|0]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[5|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[6|3]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_0[5|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_0[4|7]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6_0/pad4diode_1[4|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_0/pad4diode_1[3|5]/pad3_0/m4_n10636_n5828# bondpad_array_ds_6
.ends

.subckt bondpad_array_g_top bondpad_lines_2_0/m1_59556_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|1]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_7122_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|1]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_20440_78300# bondpad_lines_2_0/m1_56500_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|3]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_25752_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|5]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_8722_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|7]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_39470_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|4]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_18840_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|6]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_49188_78300# bondpad_lines_2_0/m1_36414_78300# bondpad_lines_2_0/m1_43982_78300#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|7]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_13234_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|6]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_53044_78300# bondpad_lines_2_0/m1_22296_78300# bondpad_lines_2_0/m1_40926_78300#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|1]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_58356_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|5]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_5266_78300# bondpad_lines_2_0/m1_14834_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|3]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_54644_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|5]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_29208_78300# bondpad_lines_2_0/m1_23896_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|4]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_59956_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|1]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_55300_78300# bondpad_lines_2_0/m1_45182_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|6]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_11378_78300# bondpad_lines_2_0/m1_42126_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|0]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_7522_78300# bondpad_lines_2_0/m1_20840_78300# bondpad_lines_2_0/m1_56900_78300#
+ bondpad_lines_2_0/m1_38270_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|5]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_51188_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|0]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_35214_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|1]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_60356_78300# bondpad_lines_2_0/m1_49588_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|3]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_13634_78300# bondpad_lines_2_0/m1_4066_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|0]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_53444_78300# bondpad_lines_2_0/m1_22696_78300# bondpad_lines_2_0/m1_27352_78300#
+ bondpad_lines_2_0/m1_58756_78300# bondpad_lines_2_0/m1_28008_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|4]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_5666_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|2]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_29608_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|7]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_10178_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|1]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_37070_78300# bondpad_lines_2_0/m1_55700_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|1]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_45582_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|5]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_24952_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|3]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_7922_78300# bondpad_lines_2_0/m1_42526_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|2]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_34014_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|0]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_11778_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|5]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_38670_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|4]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_51588_78300# bondpad_lines_2_0/m1_35614_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|6]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_30008_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|6]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_60756_78300# bondpad_lines_2_0/m1_52244_78300# bondpad_lines_2_0/m1_26152_78300#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|4]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_49988_78300# bondpad_lines_2_0/m1_4466_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|5]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_9778_78300# bondpad_lines_2_0/m1_9122_78300# bondpad_lines_2_0/m1_53844_78300#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|0]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_19240_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|3]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_28408_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|5]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_44382_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|6]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_6722_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|7]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_41326_78300# bondpad_lines_2_0/m1_10578_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|0]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_15234_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|6]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_37470_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|4]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_50388_78300# bondpad_lines_2_0/m1_24296_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|0]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_34414_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|1]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_12834_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|1]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_30408_78300# bondpad_lines_2_0/m1_21240_78300# bondpad_lines_2_0/m1_52644_78300#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|2]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_57300_78300# bondpad_lines_2_0/m1_21896_78300# bondpad_lines_2_0/m1_26552_78300#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|5]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_4866_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|4]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_43182_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|6]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_28808_78300# bondpad_lines_2_0/m1_19640_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|2]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_40126_78300# bondpad_lines_2_0/m1_14034_78300# bondpad_lines_2_0/m1_44782_78300#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|5]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_41726_78300# bondpad_lines_2_0/m1_23096_78300# bondpad_lines_2_0/m1_10978_78300#
+ bondpad_lines_2_0/m1_59156_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|3]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_37870_78300# bondpad_lines_2_0/m1_6066_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|5]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_50788_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|4]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_34814_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|0]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_20040_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|0]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_56100_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|7]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_25352_78300# VSUBS bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|0]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_3666_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|7]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_8322_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|4]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_12178_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|7]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_39070_78300# bondpad_lines_2_0/m1_57700_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|2]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_26952_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|3]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_36014_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|7]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_43582_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|1]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_40526_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|6]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_14434_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|4]/pad3_0/m4_n10636_n5828#
+ bondpad_lines_2_0/m1_54244_78300# bondpad_lines_2_0/m1_23496_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|4]/pad3_0/m4_n10636_n5828#
Xbondpad_array_ds_6_top_0 bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|6]/pad3_0/m4_n10636_n5828#
+ VSUBS bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|7]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|6]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|1]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|0]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|3]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|2]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|5]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|4]/pad3_0/m4_n10636_n5828#
+ bondpad_array_ds_6_top
.ends

.subckt TOPLEVEL_2
Xpad4diode_0 pad4diode_0/pad3_0/m4_n10636_n5828# m5_16710_197329# VSUBS pad4diode
Xpattern_array_small_cs_TOP_0 bp_lines_horiz_vias_21/m1_18192_7966# bp_lines_horiz_vias_15/m1_3018_1566#
+ bp_lines_horiz_vias_17/m1_9130_4766# bp_lines_horiz_vias_21/m1_9130_4766# bp_lines_horiz_vias_5/m1_15136_6366#
+ bp_lines_horiz_vias_11/m1_21248_9566# bp_lines_horiz_vias_3/m1_21248_9566# bp_lines_horiz_vias_24/m1_n38_n34#
+ bp_lines_horiz_vias_23/m1_18192_7966# bp_lines_horiz_vias_20/m1_6074_3166# bp_lines_horiz_vias_23/m1_9130_4766#
+ bp_lines_horiz_vias_19/m1_18192_7966# bp_lines_horiz_vias_15/m1_6074_3166# bp_lines_horiz_vias_7/m1_3018_1566#
+ bp_lines_horiz_vias_14/m1_21248_9566# bp_lines_horiz_vias_15/m1_21248_9566# bp_lines_horiz_vias_1/m1_15136_6366#
+ bp_lines_horiz_vias_19/m1_15136_6366# bp_lines_horiz_vias_16/m1_18192_7966# bp_lines_horiz_vias_2/m1_3018_1566#
+ bp_lines_horiz_vias_2/m1_9130_4766# bp_lines_horiz_vias_8/m1_15136_6366# bp_lines_horiz_vias_7/m1_n38_n34#
+ bp_lines_horiz_vias_24/m1_21248_9566# bp_lines_horiz_vias_18/m1_21248_9566# bp_lines_horiz_vias_10/m1_9130_4766#
+ bp_lines_horiz_vias_25/m1_24304_11166# bp_lines_horiz_vias_16/m1_n38_n34# bp_lines_horiz_vias_10/m1_18192_7966#
+ bp_lines_horiz_vias_25/m1_3018_1566# bp_lines_horiz_vias_16/m1_15136_6366# bp_lines_horiz_vias_2/m1_18192_7966#
+ bp_lines_horiz_vias_10/m1_6074_3166# bp_lines_horiz_vias_8/m1_24304_11166# bp_lines_horiz_vias_6/m1_3018_1566#
+ bp_lines_horiz_vias_20/m1_24304_11166# bp_lines_horiz_vias_6/m1_9130_4766# bp_lines_horiz_vias_27/m1_6074_3166#
+ bp_lines_horiz_vias_7/m1_18192_7966# bp_lines_horiz_vias_4/m1_24304_11166# bp_lines_horiz_vias_12/m1_24304_11166#
+ bp_lines_horiz_vias_6/m1_18192_7966# bp_lines_horiz_vias_22/m1_15136_6366# bp_lines_horiz_vias_14/m1_3018_1566#
+ bp_lines_horiz_vias_8/m1_21248_9566# bp_lines_horiz_vias_18/m1_9130_4766# bp_lines_horiz_vias_21/m1_n38_n34#
+ bp_lines_horiz_vias_13/m1_9130_4766# bp_lines_horiz_vias_26/m1_15136_6366# bp_lines_horiz_vias_27/m1_18192_7966#
+ bp_lines_horiz_vias_13/m1_6074_3166# bp_lines_horiz_vias_5/m1_6074_3166# bp_lines_horiz_vias_5/m1_n38_n34#
+ bp_lines_horiz_vias_27/m1_9130_4766# bp_lines_horiz_vias_12/m1_21248_9566# bp_lines_horiz_vias_11/m1_3018_1566#
+ bp_lines_horiz_vias_6/m1_15136_6366# bp_lines_horiz_vias_16/m1_3018_1566# bp_lines_horiz_vias_13/m1_15136_6366#
+ bp_lines_horiz_vias_14/m1_6074_3166# bp_lines_horiz_vias_21/m1_21248_9566# bp_lines_horiz_vias_11/m1_n38_n34#
+ bp_lines_horiz_vias_23/m1_n38_n34# bp_lines_horiz_vias_13/m1_24304_11166# bp_lines_horiz_vias_9/m1_15136_6366#
+ bp_lines_horiz_vias_3/m1_3018_1566# bp_lines_horiz_vias_20/m1_n38_n34# bp_lines_horiz_vias_3/m1_9130_4766#
+ bp_lines_horiz_vias_23/m1_21248_9566# bp_lines_horiz_vias_16/m1_6074_3166# bp_lines_horiz_vias_11/m1_18192_7966#
+ bp_lines_horiz_vias_1/m1_24304_11166# bp_lines_horiz_vias_3/m1_18192_7966# bp_lines_horiz_vias_15/m1_24304_11166#
+ bp_lines_horiz_vias_24/m1_24304_11166# bp_lines_horiz_vias_0/m1_21248_9566# bp_lines_horiz_vias_9/m1_24304_11166#
+ bp_lines_horiz_vias_24/m1_3018_1566# bp_lines_horiz_vias_22/m1_6074_3166# bp_lines_horiz_vias_19/m1_24304_11166#
+ bp_lines_horiz_vias_5/m1_24304_11166# bp_lines_horiz_vias_26/m1_6074_3166# bp_lines_horiz_vias_2/m1_6074_3166#
+ bp_lines_horiz_vias_2/m1_n38_n34# bp_lines_horiz_vias_19/m1_9130_4766# bp_lines_horiz_vias_9/m1_21248_9566#
+ bp_lines_horiz_vias_8/m1_3018_1566# bp_lines_horiz_vias_7/m1_9130_4766# bp_lines_horiz_vias_1/m1_21248_9566#
+ bp_lines_horiz_vias_20/m1_18192_7966# bp_lines_horiz_vias_25/m1_15136_6366# bp_lines_horiz_vias_22/m1_18192_7966#
+ bp_lines_horiz_vias_17/m1_n38_n34# bp_lines_horiz_vias_27/m1_n38_n34# bp_lines_horiz_vias_7/m1_6074_3166#
+ bp_lines_horiz_vias_6/m1_n38_n34# bp_lines_horiz_vias_6/m1_6074_3166# bp_lines_horiz_vias_8/m1_n38_n34#
+ bp_lines_horiz_vias_22/m1_9130_4766# bp_lines_horiz_vias_26/m1_18192_7966# bp_lines_horiz_vias_20/m1_15136_6366#
+ bp_lines_horiz_vias_19/m1_21248_9566# bp_lines_horiz_vias_17/m1_18192_7966# bp_lines_horiz_vias_17/m1_3018_1566#
+ bp_lines_horiz_vias_26/m1_9130_4766# bp_lines_horiz_vias_12/m1_3018_1566# bp_lines_horiz_vias_17/m1_15136_6366#
+ bp_lines_horiz_vias_7/m1_15136_6366# bp_lines_horiz_vias_16/m1_21248_9566# bp_lines_horiz_vias_12/m1_n38_n34#
+ bp_lines_horiz_vias_27/m1_21248_9566# bp_lines_horiz_vias_6/m1_24304_11166# bp_lines_horiz_vias_7/m1_24304_11166#
+ bp_lines_horiz_vias_8/m1_18192_7966# bp_lines_horiz_vias_4/m1_21248_9566# bp_lines_horiz_vias_10/m1_15136_6366#
+ bp_lines_horiz_vias_21/m1_24304_11166# bp_lines_horiz_vias_4/m1_3018_1566# bp_lines_horiz_vias_21/m1_3018_1566#
+ bp_lines_horiz_vias_17/m1_6074_3166# bp_lines_horiz_vias_12/m1_18192_7966# bp_lines_horiz_vias_2/m1_24304_11166#
+ bp_lines_horiz_vias_2/m1_15136_6366# bp_lines_horiz_vias_23/m1_24304_11166# bp_lines_horiz_vias_15/m1_n38_n34#
+ bp_lines_horiz_vias_23/m1_3018_1566# bp_lines_horiz_vias_11/m1_9130_4766# bp_lines_horiz_vias_18/m1_24304_11166#
+ bp_lines_horiz_vias_11/m1_6074_3166# bp_lines_horiz_vias_3/m1_n38_n34# bp_lines_horiz_vias_20/m1_9130_4766#
+ bp_lines_horiz_vias_25/m1_6074_3166# bp_lines_horiz_vias_3/m1_6074_3166# bp_lines_horiz_vias_0/m1_3018_1566#
+ bp_lines_horiz_vias_0/m1_9130_4766# bp_lines_horiz_vias_9/m1_3018_1566# bp_lines_horiz_vias_15/m1_9130_4766#
+ bp_lines_horiz_vias_14/m1_n38_n34# bp_lines_horiz_vias_1/m1_6074_3166# bp_lines_horiz_vias_11/m1_15136_6366#
+ bp_lines_horiz_vias_22/m1_n38_n34# bp_lines_horiz_vias_24/m1_15136_6366# bp_lines_horiz_vias_0/m1_18192_7966#
+ bp_lines_horiz_vias_9/m1_n38_n34# bp_lines_horiz_vias_26/m1_n38_n34# bp_lines_horiz_vias_18/m1_3018_1566#
+ bp_lines_horiz_vias_25/m1_18192_7966# bp_lines_horiz_vias_25/m1_9130_4766# bp_lines_horiz_vias_22/m1_21248_9566#
+ bp_lines_horiz_vias_1/m1_3018_1566# bp_lines_horiz_vias_1/m1_9130_4766# bp_lines_horiz_vias_0/m1_24304_11166#
+ bp_lines_horiz_vias_1/m1_18192_7966# bp_lines_horiz_vias_0/m1_15136_6366# bp_lines_horiz_vias_9/m1_18192_7966#
+ bp_lines_horiz_vias_26/m1_21248_9566# bp_lines_horiz_vias_5/m1_21248_9566# bp_lines_horiz_vias_13/m1_21248_9566#
+ bp_lines_horiz_vias_18/m1_6074_3166# bp_lines_horiz_vias_18/m1_n38_n34# bp_lines_horiz_vias_27/m1_3018_1566#
+ bp_lines_horiz_vias_27/m1_24304_11166# bp_lines_horiz_vias_8/m1_9130_4766# bp_lines_horiz_vias_3/m1_24304_11166#
+ bp_lines_horiz_vias_3/m1_15136_6366# bp_lines_horiz_vias_8/m1_6074_3166# bp_lines_horiz_vias_14/m1_18192_7966#
+ bp_lines_horiz_vias_15/m1_18192_7966# bp_lines_horiz_vias_12/m1_9130_4766# bp_lines_horiz_vias_4/m1_9130_4766#
+ bp_lines_horiz_vias_18/m1_18192_7966# bp_lines_horiz_vias_15/m1_15136_6366# bp_lines_horiz_vias_14/m1_15136_6366#
+ bp_lines_horiz_vias_20/m1_21248_9566# bp_lines_horiz_vias_14/m1_9130_4766# bp_lines_horiz_vias_4/m1_18192_7966#
+ bp_lines_horiz_vias_18/m1_15136_6366# bp_lines_horiz_vias_17/m1_24304_11166# bp_lines_horiz_vias_12/m1_6074_3166#
+ bp_lines_horiz_vias_10/m1_24304_11166# bp_lines_horiz_vias_4/m1_6074_3166# bp_lines_horiz_vias_4/m1_n38_n34#
+ bp_lines_horiz_vias_21/m1_15136_6366# bp_lines_horiz_vias_17/m1_21248_9566# bp_lines_horiz_vias_10/m1_3018_1566#
+ bp_lines_horiz_vias_24/m1_6074_3166# bp_lines_horiz_vias_12/m1_15136_6366# bp_lines_horiz_vias_10/m1_n38_n34#
+ bp_lines_horiz_vias_19/m1_3018_1566# bp_lines_horiz_vias_23/m1_15136_6366# bp_lines_horiz_vias_16/m1_9130_4766#
+ bp_lines_horiz_vias_25/m1_n38_n34# bp_lines_horiz_vias_4/m1_15136_6366# bp_lines_horiz_vias_10/m1_21248_9566#
+ bp_lines_horiz_vias_24/m1_18192_7966# bp_lines_horiz_vias_2/m1_21248_9566# bp_lines_horiz_vias_24/m1_9130_4766#
+ bp_lines_horiz_vias_0/m1_n38_n34# bp_lines_horiz_vias_19/m1_6074_3166# bp_lines_horiz_vias_0/m1_6074_3166#
+ bp_lines_horiz_vias_13/m1_3018_1566# bp_lines_horiz_vias_7/m1_21248_9566# bp_lines_horiz_vias_22/m1_3018_1566#
+ bp_lines_horiz_vias_25/m1_21248_9566# bp_lines_horiz_vias_6/m1_21248_9566# bp_lines_horiz_vias_22/m1_24304_11166#
+ bp_lines_horiz_vias_13/m1_n38_n34# bp_lines_horiz_vias_26/m1_24304_11166# bp_lines_horiz_vias_26/m1_3018_1566#
+ bp_lines_horiz_vias_9/m1_9130_4766# m5_16710_197329# bp_lines_horiz_vias_14/m1_24304_11166#
+ bp_lines_horiz_vias_9/m1_6074_3166# bp_lines_horiz_vias_1/m1_n38_n34# bp_lines_horiz_vias_5/m1_3018_1566#
+ bp_lines_horiz_vias_21/m1_6074_3166# bp_lines_horiz_vias_5/m1_9130_4766# bp_lines_horiz_vias_13/m1_18192_7966#
+ bp_lines_horiz_vias_5/m1_18192_7966# bp_lines_horiz_vias_11/m1_24304_11166# bp_lines_horiz_vias_16/m1_24304_11166#
+ bp_lines_horiz_vias_27/m1_15136_6366# bp_lines_horiz_vias_19/m1_n38_n34# bp_lines_horiz_vias_20/m1_3018_1566#
+ bp_lines_horiz_vias_23/m1_6074_3166# pattern_array_small_cs_TOP
Xbondpad_array_g_top_0 bp_lines_horiz_vias_25/m1_24304_11166# bp_lines_horiz_vias_18/m1_6074_3166#
+ bp_lines_horiz_vias_20/m1_9130_4766# bp_lines_horiz_vias_19/m1_n38_n34# bp_lines_horiz_vias_23/m1_3018_1566#
+ bp_lines_horiz_vias_16/m1_3018_1566# bp_lines_horiz_vias_18/m1_3018_1566# bp_lines_horiz_vias_19/m1_15136_6366#
+ bp_lines_horiz_vias_25/m1_21248_9566# bp_lines_horiz_vias_25/m1_9130_4766# bp_lines_horiz_vias_17/m1_21248_9566#
+ bp_lines_horiz_vias_25/m1_n38_n34# bp_lines_horiz_vias_23/m1_6074_3166# bp_lines_horiz_vias_27/m1_18192_7966#
+ bp_lines_horiz_vias_20/m1_3018_1566# bp_lines_horiz_vias_24/m1_24304_11166# bp_lines_horiz_vias_21/m1_3018_1566#
+ bp_lines_horiz_vias_25/m1_15136_6366# bp_lines_horiz_vias_15/m1_15136_6366# bp_lines_horiz_vias_27/m1_21248_9566#
+ bp_lines_horiz_vias_22/m1_15136_6366# bp_lines_horiz_vias_21/m1_n38_n34# bp_lines_horiz_vias_24/m1_9130_4766#
+ bp_lines_horiz_vias_18/m1_24304_11166# bp_lines_horiz_vias_16/m1_9130_4766# bp_lines_horiz_vias_14/m1_6074_3166#
+ bp_lines_horiz_vias_17/m1_21248_9566# bp_lines_horiz_vias_24/m1_18192_7966# bp_lines_horiz_vias_16/m1_18192_7966#
+ bp_lines_horiz_vias_24/m1_6074_3166# bp_lines_horiz_vias_15/m1_15136_6366# bp_lines_horiz_vias_14/m1_3018_1566#
+ bp_lines_horiz_vias_22/m1_24304_11166# bp_lines_horiz_vias_17/m1_18192_7966# bp_lines_horiz_vias_19/m1_n38_n34#
+ bp_lines_horiz_vias_20/m1_9130_4766# bp_lines_horiz_vias_22/m1_9130_4766# bp_lines_horiz_vias_15/m1_9130_4766#
+ bp_lines_horiz_vias_21/m1_18192_7966# bp_lines_horiz_vias_24/m1_18192_7966# bp_lines_horiz_vias_18/m1_24304_11166#
+ bp_lines_horiz_vias_20/m1_18192_7966# bp_lines_horiz_vias_22/m1_15136_6366# bp_lines_horiz_vias_26/m1_24304_11166#
+ bp_lines_horiz_vias_21/m1_3018_1566# bp_lines_horiz_vias_22/m1_21248_9566# bp_lines_horiz_vias_27/m1_9130_4766#
+ bp_lines_horiz_vias_24/m1_21248_9566# bp_lines_horiz_vias_21/m1_6074_3166# bp_lines_horiz_vias_20/m1_21248_9566#
+ bp_lines_horiz_vias_19/m1_6074_3166# bp_lines_horiz_vias_27/m1_6074_3166# bp_lines_horiz_vias_18/m1_n38_n34#
+ bp_lines_horiz_vias_17/m1_3018_1566# bp_lines_horiz_vias_20/m1_15136_6366# bp_lines_horiz_vias_26/m1_21248_9566#
+ bp_lines_horiz_vias_25/m1_3018_1566# bp_lines_horiz_vias_18/m1_15136_6366# bp_lines_horiz_vias_20/m1_18192_7966#
+ bp_lines_horiz_vias_27/m1_15136_6366# bp_lines_horiz_vias_16/m1_6074_3166# bp_lines_horiz_vias_21/m1_n38_n34#
+ bp_lines_horiz_vias_25/m1_n38_n34# bp_lines_horiz_vias_18/m1_9130_4766# bp_lines_horiz_vias_25/m1_24304_11166#
+ bp_lines_horiz_vias_16/m1_3018_1566# bp_lines_horiz_vias_25/m1_3018_1566# bp_lines_horiz_vias_27/m1_24304_11166#
+ bp_lines_horiz_vias_23/m1_15136_6366# bp_lines_horiz_vias_27/m1_9130_4766# bp_lines_horiz_vias_17/m1_9130_4766#
+ bp_lines_horiz_vias_16/m1_n38_n34# bp_lines_horiz_vias_15/m1_24304_11166# bp_lines_horiz_vias_25/m1_6074_3166#
+ bp_lines_horiz_vias_24/m1_n38_n34# bp_lines_horiz_vias_25/m1_18192_7966# bp_lines_horiz_vias_17/m1_18192_7966#
+ bp_lines_horiz_vias_14/m1_21248_9566# bp_lines_horiz_vias_23/m1_24304_11166# bp_lines_horiz_vias_15/m1_24304_11166#
+ bp_lines_horiz_vias_27/m1_15136_6366# bp_lines_horiz_vias_14/m1_15136_6366# bp_lines_horiz_vias_20/m1_n38_n34#
+ bp_lines_horiz_vias_19/m1_6074_3166# bp_lines_horiz_vias_19/m1_24304_11166# bp_lines_horiz_vias_14/m1_9130_4766#
+ bp_lines_horiz_vias_15/m1_21248_9566# bp_lines_horiz_vias_19/m1_24304_11166# bp_lines_horiz_vias_16/m1_6074_3166#
+ bp_lines_horiz_vias_22/m1_3018_1566# bp_lines_horiz_vias_22/m1_3018_1566# bp_lines_horiz_vias_23/m1_21248_9566#
+ bp_lines_horiz_vias_19/m1_3018_1566# bp_lines_horiz_vias_21/m1_9130_4766# bp_lines_horiz_vias_15/m1_18192_7966#
+ bp_lines_horiz_vias_15/m1_21248_9566# bp_lines_horiz_vias_24/m1_9130_4766# bp_lines_horiz_vias_18/m1_3018_1566#
+ bp_lines_horiz_vias_21/m1_6074_3166# bp_lines_horiz_vias_22/m1_6074_3166# bp_lines_horiz_vias_22/m1_n38_n34#
+ bp_lines_horiz_vias_17/m1_n38_n34# bp_lines_horiz_vias_20/m1_6074_3166# bp_lines_horiz_vias_26/m1_18192_7966#
+ bp_lines_horiz_vias_26/m1_3018_1566# bp_lines_horiz_vias_24/m1_15136_6366# bp_lines_horiz_vias_21/m1_15136_6366#
+ bp_lines_horiz_vias_26/m1_n38_n34# bp_lines_horiz_vias_26/m1_21248_9566# bp_lines_horiz_vias_20/m1_24304_11166#
+ bp_lines_horiz_vias_26/m1_24304_11166# bp_lines_horiz_vias_18/m1_21248_9566# bp_lines_horiz_vias_21/m1_24304_11166#
+ bp_lines_horiz_vias_22/m1_18192_7966# bp_lines_horiz_vias_18/m1_21248_9566# bp_lines_horiz_vias_16/m1_15136_6366#
+ bp_lines_horiz_vias_24/m1_15136_6366# bp_lines_horiz_vias_17/m1_n38_n34# bp_lines_horiz_vias_18/m1_18192_7966#
+ bp_lines_horiz_vias_15/m1_6074_3166# bp_lines_horiz_vias_14/m1_3018_1566# bp_lines_horiz_vias_26/m1_18192_7966#
+ bp_lines_horiz_vias_27/m1_n38_n34# bp_lines_horiz_vias_16/m1_15136_6366# bp_lines_horiz_vias_16/m1_9130_4766#
+ bp_lines_horiz_vias_16/m1_24304_11166# bp_lines_horiz_vias_27/m1_3018_1566# bp_lines_horiz_vias_23/m1_18192_7966#
+ bp_lines_horiz_vias_25/m1_9130_4766# bp_lines_horiz_vias_23/m1_21248_9566# bp_lines_horiz_vias_15/m1_3018_1566#
+ bp_lines_horiz_vias_27/m1_6074_3166# bp_lines_horiz_vias_16/m1_24304_11166# bp_lines_horiz_vias_25/m1_6074_3166#
+ bp_lines_horiz_vias_17/m1_6074_3166# bp_lines_horiz_vias_23/m1_n38_n34# bp_lines_horiz_vias_14/m1_9130_4766#
+ bp_lines_horiz_vias_14/m1_21248_9566# bp_lines_horiz_vias_23/m1_3018_1566# bp_lines_horiz_vias_19/m1_15136_6366#
+ bp_lines_horiz_vias_25/m1_15136_6366# bp_lines_horiz_vias_14/m1_18192_7966# bp_lines_horiz_vias_14/m1_18192_7966#
+ bp_lines_horiz_vias_14/m1_n38_n34# bp_lines_horiz_vias_23/m1_n38_n34# bp_lines_horiz_vias_17/m1_6074_3166#
+ bp_lines_horiz_vias_16/m1_n38_n34# bp_lines_horiz_vias_20/m1_24304_11166# bp_lines_horiz_vias_19/m1_9130_4766#
+ bp_lines_horiz_vias_17/m1_3018_1566# bp_lines_horiz_vias_15/m1_9130_4766# bp_lines_horiz_vias_22/m1_24304_11166#
+ bp_lines_horiz_vias_24/m1_3018_1566# bp_lines_horiz_vias_14/m1_24304_11166# bp_lines_horiz_vias_14/m1_15136_6366#
+ bp_lines_horiz_vias_23/m1_18192_7966# bp_lines_horiz_vias_27/m1_24304_11166# bp_lines_horiz_vias_26/m1_9130_4766#
+ bp_lines_horiz_vias_24/m1_6074_3166# bp_lines_horiz_vias_27/m1_21248_9566# bp_lines_horiz_vias_15/m1_18192_7966#
+ bp_lines_horiz_vias_19/m1_21248_9566# bp_lines_horiz_vias_21/m1_18192_7966# bp_lines_horiz_vias_18/m1_n38_n34#
+ bp_lines_horiz_vias_26/m1_15136_6366# bp_lines_horiz_vias_22/m1_9130_4766# bp_lines_horiz_vias_21/m1_21248_9566#
+ bp_lines_horiz_vias_17/m1_24304_11166# bp_lines_horiz_vias_17/m1_15136_6366# bp_lines_horiz_vias_16/m1_21248_9566#
+ bp_lines_horiz_vias_20/m1_6074_3166# bp_lines_horiz_vias_22/m1_6074_3166# bp_lines_horiz_vias_18/m1_9130_4766#
+ bp_lines_horiz_vias_26/m1_9130_4766# bp_lines_horiz_vias_20/m1_3018_1566# bp_lines_horiz_vias_16/m1_18192_7966#
+ bp_lines_horiz_vias_26/m1_6074_3166# bp_lines_horiz_vias_18/m1_18192_7966# bp_lines_horiz_vias_18/m1_6074_3166#
+ bp_lines_horiz_vias_24/m1_24304_11166# bp_lines_horiz_vias_26/m1_n38_n34# bp_lines_horiz_vias_23/m1_9130_4766#
+ bp_lines_horiz_vias_24/m1_3018_1566# bp_lines_horiz_vias_14/m1_n38_n34# bp_lines_horiz_vias_25/m1_18192_7966#
+ bp_lines_horiz_vias_26/m1_15136_6366# bp_lines_horiz_vias_23/m1_15136_6366# bp_lines_horiz_vias_24/m1_n38_n34#
+ bp_lines_horiz_vias_20/m1_n38_n34# bp_lines_horiz_vias_18/m1_15136_6366# bp_lines_horiz_vias_25/m1_21248_9566#
+ bp_lines_horiz_vias_15/m1_n38_n34# bp_lines_horiz_vias_24/m1_21248_9566# bp_lines_horiz_vias_17/m1_24304_11166#
+ bp_lines_horiz_vias_16/m1_21248_9566# VSUBS bp_lines_horiz_vias_19/m1_21248_9566#
+ bp_lines_horiz_vias_22/m1_n38_n34# bp_lines_horiz_vias_15/m1_n38_n34# bp_lines_horiz_vias_23/m1_24304_11166#
+ bp_lines_horiz_vias_19/m1_3018_1566# bp_lines_horiz_vias_17/m1_15136_6366# bp_lines_horiz_vias_14/m1_6074_3166#
+ bp_lines_horiz_vias_19/m1_18192_7966# bp_lines_horiz_vias_21/m1_24304_11166# bp_lines_horiz_vias_27/m1_3018_1566#
+ bp_lines_horiz_vias_21/m1_21248_9566# bp_lines_horiz_vias_15/m1_6074_3166# bp_lines_horiz_vias_20/m1_21248_9566#
+ bp_lines_horiz_vias_17/m1_9130_4766# bp_lines_horiz_vias_27/m1_n38_n34# bp_lines_horiz_vias_14/m1_24304_11166#
+ bp_lines_horiz_vias_23/m1_9130_4766# bp_lines_horiz_vias_22/m1_18192_7966# bp_lines_horiz_vias_15/m1_3018_1566#
+ bp_lines_horiz_vias_26/m1_3018_1566# bp_lines_horiz_vias_23/m1_6074_3166# bp_lines_horiz_vias_21/m1_9130_4766#
+ bp_lines_horiz_vias_22/m1_21248_9566# bp_lines_horiz_vias_19/m1_9130_4766# bp_lines_horiz_vias_26/m1_6074_3166#
+ bp_lines_horiz_vias_21/m1_15136_6366# bp_lines_horiz_vias_27/m1_18192_7966# bp_lines_horiz_vias_19/m1_18192_7966#
+ bp_lines_horiz_vias_20/m1_15136_6366# bondpad_array_g_top
Xbondpad_array_ds_6_top_0 bp_lines_horiz_vias_10/m1_n38_n34# bp_lines_horiz_vias_12/m1_21248_9566#
+ bp_lines_horiz_vias_1/m1_24304_11166# bp_lines_horiz_vias_4/m1_21248_9566# bp_lines_horiz_vias_2/m1_15136_6366#
+ bp_lines_horiz_vias_4/m1_18192_7966# bp_lines_horiz_vias_4/m1_n38_n34# bp_lines_horiz_vias_5/m1_24304_11166#
+ bp_lines_horiz_vias_2/m1_9130_4766# bp_lines_horiz_vias_9/m1_18192_7966# bp_lines_horiz_vias_13/m1_3018_1566#
+ bp_lines_horiz_vias_11/m1_24304_11166# bp_lines_horiz_vias_9/m1_21248_9566# bp_lines_horiz_vias_13/m1_6074_3166#
+ bp_lines_horiz_vias_0/m1_21248_9566# bp_lines_horiz_vias_5/m1_15136_6366# bp_lines_horiz_vias_0/m1_18192_7966#
+ bp_lines_horiz_vias_3/m1_6074_3166# bp_lines_horiz_vias_5/m1_9130_4766# bp_lines_horiz_vias_3/m1_3018_1566#
+ bp_lines_horiz_vias_10/m1_3018_1566# bp_lines_horiz_vias_13/m1_n38_n34# bp_lines_horiz_vias_12/m1_9130_4766#
+ bp_lines_horiz_vias_10/m1_6074_3166# bp_lines_horiz_vias_7/m1_18192_7966# bp_lines_horiz_vias_12/m1_15136_6366#
+ bp_lines_horiz_vias_3/m1_n38_n34# bp_lines_horiz_vias_9/m1_n38_n34# bp_lines_horiz_vias_2/m1_24304_11166#
+ bp_lines_horiz_vias_7/m1_21248_9566# bp_lines_horiz_vias_6/m1_6074_3166# bp_lines_horiz_vias_2/m1_21248_9566#
+ VSUBS bp_lines_horiz_vias_12/m1_24304_11166# bp_lines_horiz_vias_6/m1_3018_1566#
+ bp_lines_horiz_vias_2/m1_18192_7966# bp_lines_horiz_vias_6/m1_24304_11166# bp_lines_horiz_vias_9/m1_9130_4766#
+ bp_lines_horiz_vias_11/m1_18192_7966# bp_lines_horiz_vias_9/m1_15136_6366# bp_lines_horiz_vias_11/m1_21248_9566#
+ bp_lines_horiz_vias_5/m1_21248_9566# bp_lines_horiz_vias_3/m1_15136_6366# bp_lines_horiz_vias_5/m1_18192_7966#
+ bp_lines_horiz_vias_1/m1_6074_3166# bp_lines_horiz_vias_3/m1_9130_4766# bp_lines_horiz_vias_0/m1_n38_n34#
+ bp_lines_horiz_vias_8/m1_18192_7966# bp_lines_horiz_vias_2/m1_n38_n34# bp_lines_horiz_vias_1/m1_3018_1566#
+ bp_lines_horiz_vias_12/m1_3018_1566# bp_lines_horiz_vias_12/m1_n38_n34# bp_lines_horiz_vias_7/m1_9130_4766#
+ bp_lines_horiz_vias_8/m1_21248_9566# bp_lines_horiz_vias_8/m1_24304_11166# bp_lines_horiz_vias_12/m1_6074_3166#
+ bp_lines_horiz_vias_13/m1_24304_11166# bp_lines_horiz_vias_7/m1_15136_6366# bp_lines_horiz_vias_6/m1_15136_6366#
+ bp_lines_horiz_vias_3/m1_24304_11166# bp_lines_horiz_vias_8/m1_n38_n34# bp_lines_horiz_vias_4/m1_6074_3166#
+ bp_lines_horiz_vias_6/m1_9130_4766# bp_lines_horiz_vias_9/m1_3018_1566# bp_lines_horiz_vias_4/m1_3018_1566#
+ bp_lines_horiz_vias_11/m1_9130_4766# bp_lines_horiz_vias_0/m1_24304_11166# bp_lines_horiz_vias_9/m1_6074_3166#
+ bp_lines_horiz_vias_13/m1_18192_7966# bp_lines_horiz_vias_11/m1_15136_6366# bp_lines_horiz_vias_13/m1_21248_9566#
+ bp_lines_horiz_vias_6/m1_n38_n34# bp_lines_horiz_vias_0/m1_6074_3166# bp_lines_horiz_vias_3/m1_21248_9566#
+ bp_lines_horiz_vias_1/m1_n38_n34# bp_lines_horiz_vias_1/m1_15136_6366# bp_lines_horiz_vias_0/m1_3018_1566#
+ bp_lines_horiz_vias_3/m1_18192_7966# bp_lines_horiz_vias_9/m1_24304_11166# bp_lines_horiz_vias_8/m1_9130_4766#
+ bp_lines_horiz_vias_7/m1_24304_11166# bp_lines_horiz_vias_1/m1_9130_4766# bp_lines_horiz_vias_10/m1_18192_7966#
+ bp_lines_horiz_vias_7/m1_3018_1566# bp_lines_horiz_vias_8/m1_15136_6366# bp_lines_horiz_vias_11/m1_n38_n34#
+ bp_lines_horiz_vias_10/m1_21248_9566# bp_lines_horiz_vias_7/m1_6074_3166# bp_lines_horiz_vias_6/m1_21248_9566#
+ bp_lines_horiz_vias_4/m1_15136_6366# bp_lines_horiz_vias_6/m1_18192_7966# bp_lines_horiz_vias_2/m1_6074_3166#
+ bp_lines_horiz_vias_4/m1_24304_11166# bp_lines_horiz_vias_4/m1_9130_4766# bp_lines_horiz_vias_2/m1_3018_1566#
+ bp_lines_horiz_vias_11/m1_3018_1566# bp_lines_horiz_vias_13/m1_9130_4766# bp_lines_horiz_vias_5/m1_n38_n34#
+ bp_lines_horiz_vias_11/m1_6074_3166# bp_lines_horiz_vias_13/m1_15136_6366# bp_lines_horiz_vias_10/m1_24304_11166#
+ bp_lines_horiz_vias_0/m1_15136_6366# bp_lines_horiz_vias_5/m1_6074_3166# bp_lines_horiz_vias_0/m1_9130_4766#
+ bp_lines_horiz_vias_1/m1_21248_9566# bp_lines_horiz_vias_5/m1_3018_1566# bp_lines_horiz_vias_8/m1_3018_1566#
+ bp_lines_horiz_vias_1/m1_18192_7966# bp_lines_horiz_vias_7/m1_n38_n34# bp_lines_horiz_vias_10/m1_9130_4766#
+ bp_lines_horiz_vias_8/m1_6074_3166# bp_lines_horiz_vias_12/m1_18192_7966# bp_lines_horiz_vias_10/m1_15136_6366#
+ bondpad_array_ds_6_top
.ends

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[7] io_analog[8] io_analog[9] io_analog[4]
+ io_analog[5] io_analog[6] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vdda1 vdda2 vssa1 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
XTOPLEVEL_2_0 TOPLEVEL_2
XTOPLEVEL_2_1 TOPLEVEL_2
.ends
