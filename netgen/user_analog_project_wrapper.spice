* NGSPICE file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt bp_lines_horiz_main bondpad_lines_horiz_0[6]/m2_n36_9584# bondpad_lines_horiz_0[6]/m2_n36_7984#
+ bondpad_lines_horiz_0[1]/m2_n36_n16# bondpad_lines_horiz_0[6]/m2_n36_n16# bondpad_lines_horiz_0[2]/m2_n36_11184#
+ bondpad_lines_horiz_0[4]/m2_n36_6384# bondpad_lines_horiz_0[2]/m2_n36_3184# bondpad_lines_horiz_0[4]/m2_n36_4784#
+ bondpad_lines_horiz_0[2]/m2_n36_1584# bondpad_lines_horiz_0[6]/m2_n36_11184# bondpad_lines_horiz_0[1]/m2_n36_9584#
+ bondpad_lines_horiz_0[5]/m2_n36_3184# bondpad_lines_horiz_0[5]/m2_n36_1584# bondpad_lines_horiz_0[1]/m2_n36_7984#
+ bondpad_lines_horiz_0[5]/m2_n36_n16# bondpad_lines_horiz_0[0]/m2_n36_n16# bondpad_lines_horiz_0[4]/m2_n36_7984#
+ bondpad_lines_horiz_0[4]/m2_n36_9584# bondpad_lines_horiz_0[2]/m2_n36_6384# bondpad_lines_horiz_0[2]/m2_n36_4784#
+ bondpad_lines_horiz_0[0]/m2_n36_3184# bondpad_lines_horiz_0[3]/m2_n36_11184# bondpad_lines_horiz_0[0]/m2_n36_1584#
+ bondpad_lines_horiz_0[5]/m2_n36_6384# bondpad_lines_horiz_0[3]/m2_n36_3184# bondpad_lines_horiz_0[3]/m2_n36_1584#
+ bondpad_lines_horiz_0[5]/m2_n36_4784# bondpad_lines_horiz_0[4]/m2_n36_n16# bondpad_lines_horiz_0[0]/m2_n36_11184#
+ bondpad_lines_horiz_0[2]/m2_n36_9584# bondpad_lines_horiz_0[6]/m2_n36_3184# bondpad_lines_horiz_0[4]/m2_n36_11184#
+ bondpad_lines_horiz_0[6]/m2_n36_1584# bondpad_lines_horiz_0[2]/m2_n36_7984# bondpad_lines_horiz_0[0]/m2_n36_4784#
+ bondpad_lines_horiz_0[0]/m2_n36_6384# bondpad_lines_horiz_0[3]/m2_n36_n16# bondpad_lines_horiz_0[5]/m2_n36_9584#
+ bondpad_lines_horiz_0[3]/m2_n36_6384# bondpad_lines_horiz_0[5]/m2_n36_7984# bondpad_lines_horiz_0[1]/m2_n36_3184#
+ bondpad_lines_horiz_0[3]/m2_n36_4784# bondpad_lines_horiz_0[1]/m2_n36_1584# bondpad_lines_horiz_0[6]/m2_n36_6384#
+ bondpad_lines_horiz_0[1]/m2_n36_11184# bondpad_lines_horiz_0[4]/m2_n36_3184# bondpad_lines_horiz_0[6]/m2_n36_4784#
+ bondpad_lines_horiz_0[0]/m2_n36_9584# bondpad_lines_horiz_0[4]/m2_n36_1584# bondpad_lines_horiz_0[0]/m2_n36_7984#
+ bondpad_lines_horiz_0[2]/m2_n36_n16# bondpad_lines_horiz_0[5]/m2_n36_11184# bondpad_lines_horiz_0[3]/m2_n36_9584#
+ bondpad_lines_horiz_0[1]/m2_n36_6384# bondpad_lines_horiz_0[3]/m2_n36_7984# bondpad_lines_horiz_0[1]/m2_n36_4784#
.ends

.subckt bp_lines_horiz_main_both bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_6384#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_n16# bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_3184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_11184# bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_4784#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_1584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_9584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_6384# bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_7984#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_3184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_4784#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_3184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_1584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_9584# bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_6384#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_n16# bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_7984#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_1584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_n16#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_11184# bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_4784#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_6384# bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_n16#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_n16# bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_3184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_4784# bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_11184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_11184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_1584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_9584# bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_6384#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_7984# bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_3184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_4784# bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_11184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_1584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_3184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_9584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_6384#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_7984# bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_n16#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_1584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_n16#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_6384# bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_4784#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_9584# bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_3184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_4784# bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_n16#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_1584# bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_n16#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_7984# bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_9584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_11184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_6384#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_7984# bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_3184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_4784# bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_11184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_9584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_1584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_6384# bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_7984#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_4784# bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_n16#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_6384# bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_3184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_9584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_4784#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_n16# bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_9584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_1584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_7984#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_6384# bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_11184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_7984# bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_3184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_4784# bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_1584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_9584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_11184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_11184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_6384#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_7984# bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_4784#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_3184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_11184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_n16# bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_9584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_1584# bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_7984#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_n16# bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_9584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_6384# bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_7984#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_3184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_4784#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_9584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_1584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_6384# bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_7984#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_11184# bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_3184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_4784# bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_1584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_3184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_9584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_11184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_n16#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_11184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_1584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_7984#
Xbp_lines_horiz_main_0 bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_9584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_7984# bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_n16#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_n16# bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_11184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_6384# bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_3184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_4784# bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_1584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_11184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_9584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_3184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_1584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_7984# bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_n16#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_n16# bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_7984#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_9584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_6384#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_4784# bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_3184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_11184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_1584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_6384# bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_3184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_1584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_4784#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_n16# bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_11184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_9584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_3184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_11184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_1584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_7984# bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_4784#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_6384# bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_n16#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_9584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_6384#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_7984# bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_3184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_4784# bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_1584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_6384# bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_11184#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_3184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[6]/m2_n36_4784#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_9584# bp_lines_horiz_main_0/bondpad_lines_horiz_0[4]/m2_n36_1584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[0]/m2_n36_7984# bp_lines_horiz_main_0/bondpad_lines_horiz_0[2]/m2_n36_n16#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[5]/m2_n36_11184# bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_9584#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_6384# bp_lines_horiz_main_0/bondpad_lines_horiz_0[3]/m2_n36_7984#
+ bp_lines_horiz_main_0/bondpad_lines_horiz_0[1]/m2_n36_4784# bp_lines_horiz_main
Xbp_lines_horiz_main_1 bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_9584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_7984# bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_n16#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_n16# bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_11184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_6384# bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_3184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_4784# bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_1584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_11184# bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_9584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_3184# bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_1584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_7984# bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_n16#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_n16# bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_7984#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_9584# bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_6384#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_4784# bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_3184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_11184# bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_1584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_6384# bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_3184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_1584# bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_4784#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_n16# bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_11184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_9584# bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_3184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_11184# bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_1584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_7984# bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_4784#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_6384# bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_n16#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_9584# bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_6384#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_7984# bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_3184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_4784# bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_1584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_6384# bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_11184#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_3184# bp_lines_horiz_main_1/bondpad_lines_horiz_0[6]/m2_n36_4784#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_9584# bp_lines_horiz_main_1/bondpad_lines_horiz_0[4]/m2_n36_1584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[0]/m2_n36_7984# bp_lines_horiz_main_1/bondpad_lines_horiz_0[2]/m2_n36_n16#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[5]/m2_n36_11184# bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_9584#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_6384# bp_lines_horiz_main_1/bondpad_lines_horiz_0[3]/m2_n36_7984#
+ bp_lines_horiz_main_1/bondpad_lines_horiz_0[1]/m2_n36_4784# bp_lines_horiz_main
.ends

.subckt bondpad_array_ds_6 pad4diode_0[6|6]/pad4_0/m4_n288088_n262980# pad4diode_1[4|0]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[6|3]/pad4_0/m4_n288088_n262980# pad4diode_0[1|5]/pad4_0/m4_n288088_n262980#
+ pad4diode_1[2|7]/pad4_0/m4_n288088_n262980# pad4diode_0[6|0]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[1|2]/pad4_0/m4_n288088_n262980# pad4diode_1[2|4]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[4|7]/pad4_0/m4_n288088_n262980# pad4diode_1[2|1]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[4|4]/pad4_0/m4_n288088_n262980# pad4diode_1[5|6]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[4|1]/pad4_0/m4_n288088_n262980# pad4diode_1[5|3]/pad4_0/m4_n288088_n262980#
+ pad4diode_1[0|5]/pad4_0/m4_n288088_n262980# pad4diode_1[5|0]/pad4_0/m4_n288088_n262980#
+ pad4diode_1[0|2]/pad4_0/m4_n288088_n262980# pad4diode_0[2|5]/pad4_0/m4_n288088_n262980#
+ pad4diode_1[3|7]/pad4_0/m4_n288088_n262980# pad4diode_0[2|2]/pad4_0/m4_n288088_n262980#
+ pad4diode_1[3|4]/pad4_0/m4_n288088_n262980# pad4diode_0[5|7]/pad4_0/m4_n288088_n262980#
+ pad4diode_1[3|1]/pad4_0/m4_n288088_n262980# pad4diode_0[5|4]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[0|6]/pad4_0/m4_n288088_n262980# pad4diode_1[6|6]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[5|1]/pad4_0/m4_n288088_n262980# pad4diode_0[0|3]/pad4_0/m4_n288088_n262980#
+ pad4diode_1[6|3]/pad4_0/m4_n288088_n262980# pad4diode_1[1|5]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[0|0]/pad4_0/m4_n288088_n262980# pad4diode_1[6|0]/pad4_0/m4_n288088_n262980#
+ pad4diode_1[1|2]/pad4_0/m4_n288088_n262980# pad4diode_0[3|5]/pad4_0/m4_n288088_n262980#
+ pad4diode_1[4|7]/pad4_0/m4_n288088_n262980# pad4diode_0[3|2]/pad4_0/m4_n288088_n262980#
+ pad4diode_1[4|4]/pad4_0/m4_n288088_n262980# pad4diode_1[6|7]/li_n3281_1242# pad4diode_0[6|7]/pad4_0/m4_n288088_n262980#
+ pad4diode_1[4|1]/pad4_0/m4_n288088_n262980# pad4diode_0[6|4]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[1|6]/pad4_0/m4_n288088_n262980# pad4diode_0[6|1]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[1|3]/pad4_0/m4_n288088_n262980# pad4diode_1[2|5]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[1|0]/pad4_0/m4_n288088_n262980# pad4diode_1[2|2]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[4|5]/pad4_0/m4_n288088_n262980# pad4diode_1[5|7]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[4|2]/pad4_0/m4_n288088_n262980# pad4diode_1[5|4]/pad4_0/m4_n288088_n262980#
+ pad4diode_1[0|6]/pad4_0/m4_n288088_n262980# pad4diode_1[5|1]/pad4_0/m4_n288088_n262980#
+ pad4diode_1[0|3]/pad4_0/m4_n288088_n262980# pad4diode_0[2|6]/pad4_0/m4_n288088_n262980#
+ pad4diode_1[0|0]/pad4_0/m4_n288088_n262980# pad4diode_0[2|3]/pad4_0/m4_n288088_n262980#
+ pad4diode_1[3|5]/pad4_0/m4_n288088_n262980# pad4diode_0[2|0]/pad4_0/m4_n288088_n262980#
+ pad4diode_1[3|2]/pad4_0/m4_n288088_n262980# pad4diode_0[5|5]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[0|7]/pad4_0/m4_n288088_n262980# pad4diode_1[6|7]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[5|2]/pad4_0/m4_n288088_n262980# pad4diode_0[0|4]/pad4_0/m4_n288088_n262980#
+ pad4diode_1[6|4]/pad4_0/m4_n288088_n262980# pad4diode_1[1|6]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[0|1]/pad4_0/m4_n288088_n262980# pad4diode_1[6|1]/pad4_0/m4_n288088_n262980#
+ pad4diode_1[1|3]/pad4_0/m4_n288088_n262980# pad4diode_0[3|6]/pad4_0/m4_n288088_n262980#
+ pad4diode_1[1|0]/pad4_0/m4_n288088_n262980# pad4diode_0[3|3]/pad4_0/m4_n288088_n262980#
+ pad4diode_1[4|5]/pad4_0/m4_n288088_n262980# pad4diode_0[3|0]/pad4_0/m4_n288088_n262980#
+ pad4diode_1[4|2]/pad4_0/m4_n288088_n262980# pad4diode_0[6|5]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[1|7]/pad4_0/m4_n288088_n262980# pad4diode_0[6|2]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[1|4]/pad4_0/m4_n288088_n262980# pad4diode_1[2|6]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[1|1]/pad4_0/m4_n288088_n262980# pad4diode_1[2|3]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[4|6]/pad4_0/m4_n288088_n262980# pad4diode_1[2|0]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[4|3]/pad4_0/m4_n288088_n262980# pad4diode_1[5|5]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[4|0]/pad4_0/m4_n288088_n262980# pad4diode_1[0|7]/pad4_0/m4_n288088_n262980#
+ pad4diode_1[5|2]/pad4_0/m4_n288088_n262980# pad4diode_1[0|4]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[2|7]/pad4_0/m4_n288088_n262980# pad4diode_1[0|1]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[2|4]/pad4_0/m4_n288088_n262980# pad4diode_1[3|6]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[2|1]/pad4_0/m4_n288088_n262980# pad4diode_1[3|3]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[5|6]/pad4_0/m4_n288088_n262980# pad4diode_1[3|0]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[5|3]/pad4_0/m4_n288088_n262980# pad4diode_1[6|5]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[0|5]/pad4_0/m4_n288088_n262980# pad4diode_1[1|7]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[5|0]/pad4_0/m4_n288088_n262980# pad4diode_0[0|2]/pad4_0/m4_n288088_n262980#
+ pad4diode_1[6|2]/pad4_0/m4_n288088_n262980# pad4diode_1[1|4]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[3|7]/pad4_0/m4_n288088_n262980# pad4diode_1[1|1]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[3|4]/pad4_0/m4_n288088_n262980# pad4diode_1[4|6]/pad4_0/m4_n288088_n262980#
+ pad4diode_0[3|1]/pad4_0/m4_n288088_n262980# pad4diode_1[4|3]/pad4_0/m4_n288088_n262980#
.ends

.subckt bondpad_array_ds_6_top bondpad_array_ds_6_0/pad4diode_1[5|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[0|7]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[1|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[3|6]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[2|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[2|0]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[3|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[1|0]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[6|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[5|2]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[6|7]/li_n3281_1242#
+ bondpad_array_ds_6_0/pad4diode_0[1|7]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[1|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[1|3]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[3|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[2|0]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[4|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[4|6]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[5|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[4|5]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[2|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[2|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[3|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[2|1]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[1|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[0|1]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[0|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[0|6]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[4|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[5|7]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[6|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[6|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[0|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[1|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[0|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[2|7]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[5|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[1|1]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[4|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[3|1]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[3|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[4|3]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[5|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[6|6]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[4|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[1|5]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[5|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[6|0]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[6|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[2|6]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[4|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[0|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[2|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[1|7]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[0|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[4|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[6|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[5|6]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[2|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[0|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[6|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[3|0]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[0|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[5|0]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[2|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[6|2]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[5|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[2|5]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[3|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[2|2]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[3|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[5|5]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[3|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[1|2]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[3|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[5|7]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[3|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[5|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[3|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[1|1]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[6|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[5|1]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[4|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[5|3]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[3|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[6|3]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[0|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[1|5]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[0|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[5|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[1|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[2|7]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[3|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[4|7]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[4|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[3|2]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[6|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[0|6]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[4|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[0|5]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[0|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[4|1]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[6|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[6|7]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[4|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[6|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[2|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[1|6]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[0|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[6|1]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[1|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[4|5]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[2|4]/pad4_0/m4_n288088_n262980#
Xbp_lines_horiz_main_both_0 bondpad_array_ds_6_0/pad4diode_1[1|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[4|7]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[3|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[5|7]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[1|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[3|6]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[4|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[2|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[4|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[0|2]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[2|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[0|5]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[0|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[4|1]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[6|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[6|0]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[4|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[0|6]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[1|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[4|0]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[6|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[5|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[0|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[5|7]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[3|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[5|3]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[2|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[0|0]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[3|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[1|1]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[3|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[1|2]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[5|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[3|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[6|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[5|6]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[6|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[2|6]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[0|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[2|5]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[5|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[6|1]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[0|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[0|3]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[0|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[6|1]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[2|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[0|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[1|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[2|6]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[6|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[6|2]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[5|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[3|0]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[3|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[5|5]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[1|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[3|3]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[3|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[3|1]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[1|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[5|3]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[3|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[5|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[4|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[6|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[4|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[0|6]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[6|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[2|7]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[0|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[4|1]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[0|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[2|3]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[6|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[0|2]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[4|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[2|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[4|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[3|6]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[0|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[2|0]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[1|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[3|5]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[1|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[1|5]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[4|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[3|0]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[5|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[1|6]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[5|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[3|7]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[6|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[4|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[6|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[2|2]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[4|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[2|1]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[2|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[4|3]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[2|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[5|0]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[6|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[4|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[6|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[5|2]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[1|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[1|7]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[2|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[1|0]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[5|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[1|5]/pad4_0/m4_n288088_n262980# bp_lines_horiz_main_both
Xbondpad_array_ds_6_0 bondpad_array_ds_6_0/pad4diode_0[6|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[4|0]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[6|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[1|5]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[2|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[6|0]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[1|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[2|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[4|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[2|1]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[4|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[5|6]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[4|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[5|3]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[0|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[5|0]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[0|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[2|5]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[3|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[2|2]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[3|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[5|7]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[3|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[5|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[0|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[6|6]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[5|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[0|3]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[6|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[1|5]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[0|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[6|0]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[1|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[3|5]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[4|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[3|2]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[4|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[6|7]/li_n3281_1242# bondpad_array_ds_6_0/pad4diode_0[6|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[4|1]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[6|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[1|6]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[6|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[1|3]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[2|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[1|0]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[2|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[4|5]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[5|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[4|2]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[5|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[0|6]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[5|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[0|3]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[2|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[0|0]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[2|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[3|5]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[2|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[3|2]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[5|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[0|7]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[6|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[5|2]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[0|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[6|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[1|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[0|1]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[6|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[1|3]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[3|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[1|0]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[3|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[4|5]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[3|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[4|2]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[6|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[1|7]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[6|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[1|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[2|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[1|1]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[2|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[4|6]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[2|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[4|3]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[5|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[4|0]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[0|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[5|2]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[0|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[2|7]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[0|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[2|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[3|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[2|1]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[3|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[5|6]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[3|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[5|3]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[6|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[0|5]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[1|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[5|0]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_0[0|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_1[6|2]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[1|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[3|7]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[1|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[3|4]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[4|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_0/pad4diode_0[3|1]/pad4_0/m4_n288088_n262980# bondpad_array_ds_6_0/pad4diode_1[4|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6
.ends

.subckt bondpad_array_g_top bondpad_lines_2_0/m1_59556_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|3]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_7122_78300# bondpad_lines_2_0/m1_56500_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|1]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_20440_78300# bondpad_lines_2_0/m1_25752_78300# bondpad_lines_2_0/m1_8722_78300#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|1]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_39470_78300# bondpad_lines_2_0/m1_18840_78300# bondpad_lines_2_0/m1_49188_78300#
+ bondpad_lines_2_0/m1_36414_78300# bondpad_lines_2_0/m1_13234_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|7]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_43982_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|7]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_53044_78300# bondpad_lines_2_0/m1_22296_78300# bondpad_lines_2_0/m1_40926_78300#
+ bondpad_lines_2_0/m1_58356_78300# bondpad_lines_2_0/m1_5266_78300# bondpad_lines_2_0/m1_14834_78300#
+ bondpad_lines_2_0/m1_54644_78300# bondpad_lines_2_0/m1_23896_78300# bondpad_lines_2_0/m1_29208_78300#
+ bondpad_lines_2_0/m1_59956_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|6]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_55300_78300# bondpad_lines_2_0/m1_45182_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|2]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_42126_78300# bondpad_lines_2_0/m1_11378_78300# bondpad_lines_2_0/m1_7522_78300#
+ bondpad_lines_2_0/m1_20840_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|4]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_56900_78300# bondpad_lines_2_0/m1_38270_78300# bondpad_lines_2_0/m1_51188_78300#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|2]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_35214_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|4]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_60356_78300# bondpad_lines_2_0/m1_49588_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|1]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_13634_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|3]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_4066_78300# bondpad_lines_2_0/m1_53444_78300# bondpad_lines_2_0/m1_22696_78300#
+ bondpad_lines_2_0/m1_27352_78300# bondpad_lines_2_0/m1_58756_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|3]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_28008_78300# bondpad_lines_2_0/m1_5666_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|2]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_29608_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|7]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_10178_78300# bondpad_lines_2_0/m1_45582_78300# bondpad_lines_2_0/m1_37070_78300#
+ bondpad_lines_2_0/m1_55700_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|5]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_24952_78300# bondpad_lines_2_0/m1_42526_78300# bondpad_lines_2_0/m1_7922_78300#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|2]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_34014_78300# bondpad_lines_2_0/m1_11778_78300# bondpad_lines_2_0/m1_38670_78300#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|4]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_51588_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|1]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_35614_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|5]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_30008_78300# bondpad_lines_2_0/m1_60756_78300# bondpad_lines_2_0/m1_52244_78300#
+ bondpad_lines_2_0/m1_26152_78300# bondpad_lines_2_0/m1_49988_78300# bondpad_lines_2_0/m1_4466_78300#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|5]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_9122_78300# bondpad_lines_2_0/m1_9778_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|2]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_53844_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|3]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_28408_78300# bondpad_lines_2_0/m1_19240_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|1]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_44382_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|6]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_6722_78300# bondpad_lines_2_0/m1_41326_78300# bondpad_lines_2_0/m1_10578_78300#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|6]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_37470_78300# bondpad_lines_2_0/m1_15234_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|0]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_50388_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|0]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_24296_78300# bondpad_lines_2_0/m1_34414_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|7]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_12834_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|6]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_52644_78300# bondpad_lines_2_0/m1_21240_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|3]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_30408_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|1]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_57300_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|2]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_21896_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|5]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_26552_78300# bondpad_lines_2_0/m1_4866_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|3]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_43182_78300# bondpad_lines_2_0/m1_28808_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|5]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_19640_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|0]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_40126_78300# bondpad_lines_2_0/m1_14034_78300# bondpad_lines_2_0/m1_44782_78300#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|7]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_41726_78300# bondpad_lines_2_0/m1_23096_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|2]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_10978_78300# bondpad_lines_2_0/m1_59156_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|4]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_37870_78300# bondpad_lines_2_0/m1_6066_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|6]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_50788_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|4]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_34814_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|3]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_20040_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|0]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_56100_78300# bondpad_lines_2_0/m1_25352_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|7]/li_n3281_1242#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|5]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_3666_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|7]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_8322_78300# bondpad_lines_2_0/m1_12178_78300# bondpad_lines_2_0/m1_39070_78300#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|2]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_57700_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|4]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_26952_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|1]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_36014_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|7]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_43582_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|1]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_40526_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|6]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_14434_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|4]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_54244_78300# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|4]/pad4_0/m4_n288088_n262980#
+ bondpad_lines_2_0/m1_23496_78300#
Xbondpad_array_ds_6_top_0 bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|7]/li_n3281_1242# bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[2|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[5|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[3|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[5|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[1|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[3|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[0|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[4|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[6|0]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|7]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|6]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[0|2]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[6|1]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_0[1|3]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[4|5]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top_0/bondpad_array_ds_6_0/pad4diode_1[2|4]/pad4_0/m4_n288088_n262980#
+ bondpad_array_ds_6_top
.ends

.subckt pattern_unit_small_cs_1x4_LVS Vs[0] Vs[1] Vs[2] Vs[3] Vg[3] Vg[2] Vg[1] Vg[0]
+ Vd
.ends

.subckt pattern_row_small_cs_LVS Vg[11] Vg[12] Vg[13] Vg[1] Vg[2] Vg[6] Vg[7] Vg[8]
+ Vg[9] Vs[10] Vs[14] Vs[1] Vs[2] Vs[4] Vs[5] Vs[7] Vs[8] Vs[9] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ Vs[11] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ Vs[12] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ Vs[15] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ Vg[10] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ Vg[15] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ Vs[6] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ Vg[4] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ Vs[0] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ Vg[5] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ Vs[13] Vd pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ Vg[14] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ Vg[3] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ Vs[3] Vg[0]
Xpattern_unit_small_cs_1x4_LVS_0[0] Vs[0] Vs[1] Vs[2] Vs[3] Vg[3] Vg[2] Vg[1] Vg[0]
+ Vd pattern_unit_small_cs_1x4_LVS
Xpattern_unit_small_cs_1x4_LVS_0[1] Vs[4] Vs[5] Vs[6] Vs[7] Vg[7] Vg[6] Vg[5] Vg[4]
+ Vd pattern_unit_small_cs_1x4_LVS
Xpattern_unit_small_cs_1x4_LVS_0[2] Vs[8] Vs[9] Vs[10] Vs[11] Vg[11] Vg[10] Vg[9]
+ Vg[8] Vd pattern_unit_small_cs_1x4_LVS
Xpattern_unit_small_cs_1x4_LVS_0[3] Vs[12] Vs[13] Vs[14] Vs[15] Vg[15] Vg[14] Vg[13]
+ Vg[12] Vd pattern_unit_small_cs_1x4_LVS
.ends

.subckt pattern_row_small_cs_6_LVS pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1]
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0] pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0]
Xpattern_unit_small_cs_1x4_LVS_0[0] pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
Xpattern_unit_small_cs_1x4_LVS_0[1] pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
Xpattern_unit_small_cs_1x4_LVS_0[2] pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
Xpattern_unit_small_cs_1x4_LVS_0[3] pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
.ends

.subckt pattern_row_small_cs_5_LVS pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2]
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1]
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2] pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3]
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0]
Xpattern_unit_small_cs_1x4_LVS_0[0] pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
Xpattern_unit_small_cs_1x4_LVS_0[1] pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
Xpattern_unit_small_cs_1x4_LVS_0[2] pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
Xpattern_unit_small_cs_1x4_LVS_0[3] pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
.ends

.subckt pattern_row_small_cs_4_LVS pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3]
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0] pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3]
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1]
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1]
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0]
Xpattern_unit_small_cs_1x4_LVS_0[0] pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
Xpattern_unit_small_cs_1x4_LVS_0[1] pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
Xpattern_unit_small_cs_1x4_LVS_0[2] pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
Xpattern_unit_small_cs_1x4_LVS_0[3] pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
.ends

.subckt pattern_row_small_cs_3_LVS pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1]
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0] pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2]
Xpattern_unit_small_cs_1x4_LVS_0[0] pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
Xpattern_unit_small_cs_1x4_LVS_0[1] pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
Xpattern_unit_small_cs_1x4_LVS_0[2] pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
Xpattern_unit_small_cs_1x4_LVS_0[3] pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
.ends

.subckt pattern_row_small_cs_2_LVS pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1]
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3]
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0]
Xpattern_unit_small_cs_1x4_LVS_0[0] pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
Xpattern_unit_small_cs_1x4_LVS_0[1] pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
Xpattern_unit_small_cs_1x4_LVS_0[2] pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
Xpattern_unit_small_cs_1x4_LVS_0[3] pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
.ends

.subckt pattern_row_small_cs_1_LVS pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1]
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0] pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[0]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[0]/m3_1990_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[2]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1190_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[0]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[2]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/pattern_unit_small_cs_LVS_R2_0[1]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[2]/pattern_unit_small_cs_LVS_R2_0[3]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[2]/m3_n10_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_1590_n10#
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_unit_small_cs_1x4_LVS_0[1]/pattern_unit_small_cs_LVS_R2_0[1]/m3_390_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_790_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/pattern_unit_small_cs_LVS_R2_0[3]/m3_n410_n10#
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0] pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2]
Xpattern_unit_small_cs_1x4_LVS_0[0] pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
Xpattern_unit_small_cs_1x4_LVS_0[1] pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
Xpattern_unit_small_cs_1x4_LVS_0[2] pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
Xpattern_unit_small_cs_1x4_LVS_0[3] pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3] pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1] pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0]
+ pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_unit_small_cs_1x4_LVS
.ends

.subckt pattern_array_small_cs_LVS pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_LVS_0/Vs[3] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_LVS_0/Vs[5]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2]
+ pattern_row_small_cs_LVS_0/Vs[11] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_LVS_0/Vs[10] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3] pattern_row_small_cs_LVS_0/Vs[2]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1] pattern_row_small_cs_LVS_0/Vg[3]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1] pattern_row_small_cs_LVS_0/Vs[4]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1]
+ pattern_row_small_cs_LVS_0/Vs[1] pattern_row_small_cs_LVS_0/Vs[12] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_LVS_0/Vg[1] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3]
+ pattern_row_small_cs_LVS_0/Vs[15] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_LVS_0/Vg[7]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_row_small_cs_LVS_0/Vg[0]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0]
+ pattern_row_small_cs_LVS_0/Vs[14] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1] pattern_row_small_cs_LVS_0/Vg[2]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1] pattern_row_small_cs_LVS_0/Vg[9]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vd
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2] pattern_row_small_cs_LVS_0/Vg[11]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3]
+ pattern_row_small_cs_LVS_0/Vs[7] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2]
+ pattern_row_small_cs_LVS_0/Vg[6] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3]
+ pattern_row_small_cs_LVS_0/Vg[12] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1] pattern_row_small_cs_LVS_0/Vg[13]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0] pattern_row_small_cs_LVS_0/Vs[0]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_LVS_0/Vs[9]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_row_small_cs_LVS_0/Vg[5]
+ pattern_row_small_cs_LVS_0/Vs[6] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3]
+ pattern_row_small_cs_LVS_0/Vg[8] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vd
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_row_small_cs_LVS_0/Vs[8]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3] pattern_row_small_cs_LVS_0/Vg[4]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0] pattern_row_small_cs_LVS_0/Vg[10]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2]
+ pattern_row_small_cs_LVS_0/Vg[15] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2] pattern_row_small_cs_LVS_0/Vg[14]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vd pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_LVS_0/Vs[13] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0] pattern_row_small_cs_LVS_0/Vd
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1]
Xpattern_row_small_cs_LVS_0 pattern_row_small_cs_LVS_0/Vg[11] pattern_row_small_cs_LVS_0/Vg[12]
+ pattern_row_small_cs_LVS_0/Vg[13] pattern_row_small_cs_LVS_0/Vg[1] pattern_row_small_cs_LVS_0/Vg[2]
+ pattern_row_small_cs_LVS_0/Vg[6] pattern_row_small_cs_LVS_0/Vg[7] pattern_row_small_cs_LVS_0/Vg[8]
+ pattern_row_small_cs_LVS_0/Vg[9] pattern_row_small_cs_LVS_0/Vs[10] pattern_row_small_cs_LVS_0/Vs[14]
+ pattern_row_small_cs_LVS_0/Vs[1] pattern_row_small_cs_LVS_0/Vs[2] pattern_row_small_cs_LVS_0/Vs[4]
+ pattern_row_small_cs_LVS_0/Vs[5] pattern_row_small_cs_LVS_0/Vs[7] pattern_row_small_cs_LVS_0/Vs[8]
+ pattern_row_small_cs_LVS_0/Vs[9] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_row_small_cs_LVS_0/Vs[11]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_row_small_cs_LVS_0/Vs[12]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_LVS_0/Vs[15] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_LVS_0/Vg[10]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2]
+ pattern_row_small_cs_LVS_0/Vg[15] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_LVS_0/Vs[6] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_LVS_0/Vg[4] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_LVS_0/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_row_small_cs_LVS_0/Vg[5]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_row_small_cs_LVS_0/Vs[13]
+ pattern_row_small_cs_LVS_0/Vd pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_LVS_0/Vg[14] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_LVS_0/Vg[3] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_LVS_0/Vs[3] pattern_row_small_cs_LVS_0/Vg[0] pattern_row_small_cs_LVS
Xpattern_row_small_cs_6_LVS_0 pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_LVS_0/Vs[10]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_LVS_0/Vs[4]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_LVS_0/Vs[7]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_LVS_0/Vs[1]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_LVS_0/Vs[14] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_LVS_0/Vs[8]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_row_small_cs_LVS_0/Vs[11]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3]
+ pattern_row_small_cs_LVS_0/Vs[5] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_LVS_0/Vs[12] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_LVS_0/Vs[2]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_LVS_0/Vs[15] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_LVS_0/Vs[9] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_LVS_0/Vs[6] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_LVS_0/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_row_small_cs_LVS_0/Vs[13]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vd
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3] pattern_row_small_cs_LVS_0/Vs[3]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0]
+ pattern_row_small_cs_6_LVS
Xpattern_row_small_cs_5_LVS_0 pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_LVS_0/Vs[10]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_LVS_0/Vs[4]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_LVS_0/Vs[7]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_LVS_0/Vs[1]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_LVS_0/Vs[14] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_LVS_0/Vs[8]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_row_small_cs_LVS_0/Vs[11]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3]
+ pattern_row_small_cs_LVS_0/Vs[5] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_LVS_0/Vs[12] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_LVS_0/Vs[2]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_LVS_0/Vs[15] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_LVS_0/Vs[9] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_LVS_0/Vs[6] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_LVS_0/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_row_small_cs_LVS_0/Vs[13]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vd
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3] pattern_row_small_cs_LVS_0/Vs[3]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0]
+ pattern_row_small_cs_5_LVS
Xpattern_row_small_cs_4_LVS_0 pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_LVS_0/Vs[10]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_LVS_0/Vs[4]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_LVS_0/Vs[7]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_LVS_0/Vs[1]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_LVS_0/Vs[14] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_LVS_0/Vs[8]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_row_small_cs_LVS_0/Vs[11]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3]
+ pattern_row_small_cs_LVS_0/Vs[5] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_LVS_0/Vs[12] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_LVS_0/Vs[2]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_LVS_0/Vs[15] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_LVS_0/Vs[9] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_LVS_0/Vs[6] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_LVS_0/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_row_small_cs_LVS_0/Vs[13]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vd
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3] pattern_row_small_cs_LVS_0/Vs[3]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0]
+ pattern_row_small_cs_4_LVS
Xpattern_row_small_cs_3_LVS_0 pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2]
+ pattern_row_small_cs_LVS_0/Vs[10] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2]
+ pattern_row_small_cs_LVS_0/Vs[4] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_LVS_0/Vs[7] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_LVS_0/Vs[1] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_LVS_0/Vs[14] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_LVS_0/Vs[8] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_row_small_cs_LVS_0/Vs[11]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3]
+ pattern_row_small_cs_LVS_0/Vs[5] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_row_small_cs_LVS_0/Vs[12]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_LVS_0/Vs[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_LVS_0/Vs[15]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_LVS_0/Vs[9]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_row_small_cs_LVS_0/Vs[6]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_row_small_cs_LVS_0/Vs[0] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_LVS_0/Vs[13] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vd
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_row_small_cs_LVS_0/Vs[3]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2]
+ pattern_row_small_cs_3_LVS
Xpattern_row_small_cs_2_LVS_0 pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_LVS_0/Vs[10]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_LVS_0/Vs[4]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_LVS_0/Vs[7]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_LVS_0/Vs[1]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_LVS_0/Vs[14] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_LVS_0/Vs[8]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_row_small_cs_LVS_0/Vs[11]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3]
+ pattern_row_small_cs_LVS_0/Vs[5] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_LVS_0/Vs[12] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_LVS_0/Vs[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_LVS_0/Vs[15] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_LVS_0/Vs[9] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_LVS_0/Vs[6] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_LVS_0/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_row_small_cs_LVS_0/Vs[13]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vd
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3] pattern_row_small_cs_LVS_0/Vs[3]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0]
+ pattern_row_small_cs_2_LVS
Xpattern_row_small_cs_1_LVS_0 pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_LVS_0/Vs[10]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_LVS_0/Vs[4]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_LVS_0/Vs[7]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_LVS_0/Vs[1]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_LVS_0/Vs[14] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_LVS_0/Vs[8]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[0]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_row_small_cs_LVS_0/Vs[11]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[3]
+ pattern_row_small_cs_LVS_0/Vs[5] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[0] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_LVS_0/Vs[12] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[1] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[3] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[2] pattern_row_small_cs_LVS_0/Vs[2]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0] pattern_row_small_cs_LVS_0/Vs[15]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_LVS_0/Vs[9]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[2] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[1] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[0]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[2] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2]
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[3]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vg[1] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_LVS_0/Vs[6] pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[0] pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[3] pattern_row_small_cs_LVS_0/Vs[0]
+ pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[3] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vg[1]
+ pattern_row_small_cs_6_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[2] pattern_row_small_cs_4_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[1]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[2]
+ pattern_row_small_cs_LVS_0/Vs[13] pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[2]/Vs[3]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vg[2]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[2] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vd
+ pattern_row_small_cs_5_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[1]
+ pattern_row_small_cs_2_LVS_0/pattern_unit_small_cs_1x4_LVS_0[1]/Vs[1] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[3]
+ pattern_row_small_cs_3_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vs[3] pattern_row_small_cs_LVS_0/Vs[3]
+ pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[0]/Vg[0] pattern_row_small_cs_1_LVS_0/pattern_unit_small_cs_1x4_LVS_0[3]/Vs[2]
+ pattern_row_small_cs_1_LVS
.ends

.subckt pattern_array_small_cs_TOP_LVS Vg[0] Vg[7] Vg[14] Vg[35] Vg[70] Vg[8] Vg[15]
+ Vg[36] Vg[43] Vg[50] Vg[2] Vg[16] Vg[51] Vg[72] Vg[86] Vg[100] Vg[3] Vg[38] Vg[87]
+ Vg[32] Vg[39] Vg[53] Vg[5] Vg[19] Vg[54] Vg[61] Vg[68] Vg[89] Vg[110] Vg[6] Vg[34]
+ Vg[55] Vg[69] Vg[111] Vs[0] Vs[3] Vs[4] Vs[6] Vs[7] Vs[8] Vs[9] Vs[11] Vs[16] Vs[17]
+ Vs[20] Vs[21] Vs[22] Vs[23] Vs[24] Vs[27] Vs[30] Vs[31] Vs[32] Vs[34] Vs[35] Vs[36]
+ Vs[38] Vs[39] Vs[40] Vs[46] Vs[51] Vs[55] Vs[57] Vs[58] Vs[59] Vs[64] Vs[70] Vs[71]
+ Vs[72] Vs[73] Vs[74] Vs[75] Vs[77] Vs[78] Vs[79] Vs[81] Vs[87] Vs[88] Vs[92] Vs[93]
+ Vs[94] Vs[96] Vs[97] Vs[98] Vs[99] Vs[100] Vs[101] Vs[102] Vs[103] Vs[104] Vs[105]
+ Vs[106] Vs[107] Vs[108] Vs[109] Vd Vs[41] Vs[65] Vg[103] Vs[43] Vs[68] Vs[47] Vs[61]
+ Vs[25] Vg[95] Vg[102] Vg[90] Vs[44] Vg[41] Vg[24] Vg[44] Vs[69] Vg[94] Vs[28] Vs[12]
+ Vg[60] Vs[84] Vs[62] Vg[23] Vg[48] Vs[26] Vg[74] Vg[22] Vg[101] Vg[109] Vs[52] Vg[76]
+ Vg[67] Vg[81] Vs[82] Vg[47] Vg[93] Vs[18] Vg[59] Vs[33] Vs[66] Vg[97] Vg[21] Vg[83]
+ Vs[89] Vg[107] Vg[27] Vs[110] Vg[73] Vs[85] Vg[85] Vg[80] Vs[37] Vg[42] Vs[49] Vs[1]
+ Vs[48] Vg[46] Vg[13] Vg[49] Vg[58] Vs[53] Vg[99] Vg[92] Vs[5] Vg[77] Vg[12] Vs[15]
+ Vg[65] Vg[40] Vg[108] Vg[106] Vs[63] Vs[83] Vg[75] Vs[42] Vg[84] Vg[66] Vg[20] Vg[31]
+ Vg[26] Vg[63] Vs[56] Vg[33] Vs[76] Vg[28] Vs[19] Vg[62] Vg[91] Vs[67] Vs[90] Vg[79]
+ Vs[10] Vg[1] Vs[60] Vg[4] Vg[98] Vg[88] Vg[96] Vg[45] Vg[82] Vs[54] Vg[10] Vs[111]
+ Vs[91] Vg[11] Vg[104] Vg[105] Vs[45] Vg[52] Vs[86] Vg[29] Vg[18] Vs[95] Vg[64] Vs[50]
+ Vs[2] Vg[9] Vs[29] Vs[13] Vg[56] Vg[30] Vg[25] Vs[14] Vg[71] Vg[17] Vs[80] Vg[57]
+ Vg[37] Vg[78]
Xpattern_array_small_cs_LVS_0 Vs[45] Vs[86] Vs[95] Vs[50] Vs[29] Vs[8] Vs[80] Vs[73]
+ Vs[12] Vs[16] Vs[27] Vs[64] Vs[87] Vs[57] Vs[41] Vs[21] Vs[4] Vs[55] Vs[92] Vs[34]
+ Vs[35] Vs[103] Vs[46] Vs[77] Vg[2] Vs[51] Vs[30] Vs[70] Vs[9] Vs[24] Vs[81] Vg[3]
+ Vs[74] Vs[38] Vs[17] Vs[107] Vs[65] Vs[88] Vs[58] Vs[1] Vs[31] Vs[100] Vs[43] Vg[76]
+ Vs[5] Vg[104] Vs[20] Vs[104] Vs[68] Vs[47] Vg[83] Vs[61] Vs[78] Vs[71] Vs[10] Vs[25]
+ Vs[96] Vg[109] Vs[39] Vs[108] Vg[75] Vs[2] Vs[13] Vg[22] Vs[14] Vs[32] Vg[23] Vg[48]
+ Vs[101] Vs[44] Vg[95] Vg[96] Vg[21] Vg[103] Vg[111] Vg[101] Vs[69] Vg[69] Vs[28]
+ Vg[24] Vg[67] Vs[7] Vs[84] Vs[62] Vg[108] Vg[97] Vs[22] Vs[79] Vg[74] Vs[93] Vs[72]
+ Vs[36] Vg[7] Vg[25] Vs[105] Vs[26] Vg[87] Vg[40] Vg[50] Vg[61] Vg[33] Vs[97] Vg[6]
+ Vs[40] Vs[52] Vg[49] Vs[109] Vg[0] Vg[93] Vg[88] Vs[98] Vs[82] Vg[100] Vg[62] Vg[13]
+ Vg[14] Vs[3] Vs[75] Vg[66] Vg[63] Vs[18] Vs[33] Vg[36] Vg[107] Vs[102] Vs[66] Vg[60]
+ Vg[89] Vg[32] Vg[27] Vs[89] Vg[15] Vg[29] Vg[73] Vs[59] Vg[86] Vd Vd Vg[94] Vg[39]
+ Vg[20] Vg[85] Vg[78] Vs[110] Vg[102] Vg[5] Vs[85] Vs[23] Vg[110] Vg[68] Vs[6] Vg[92]
+ Vg[46] Vg[77] Vs[94] Vs[37] Vg[58] Vg[53] Vs[49] Vs[106] Vs[48] Vg[99] Vg[42] Vg[54]
+ Vg[84] Vg[12] Vg[10] Vg[65] Vg[90] Vs[53] Vg[41] Vg[91] Vg[31] Vs[0] Vg[26] Vg[80]
+ Vg[43] Vs[11] Vs[15] Vg[34] Vg[55] Vs[99] Vs[83] Vs[63] Vd Vg[35] Vs[42] Vg[9] Vg[38]
+ Vg[79] Vg[56] Vd Vs[76] Vs[56] Vg[51] Vg[28] Vs[19] Vg[17] Vg[4] Vg[70] Vg[81] Vg[44]
+ Vg[105] Vs[67] Vg[72] Vg[106] Vs[90] Vg[1] Vd Vg[19] Vg[11] Vg[8] Vs[60] Vg[37]
+ Vg[52] Vg[57] Vg[47] Vg[98] Vd Vg[71] Vg[59] Vg[16] Vg[82] Vs[54] Vg[45] Vs[111]
+ Vs[91] Vg[18] Vg[30] Vd Vg[64] pattern_array_small_cs_LVS
.ends

.subckt TOPLEVEL_2_LVSCLEAN Vd Vg[0] Vg[100] Vg[101] Vg[102] Vg[103] Vg[104] Vg[105]
+ Vg[106] Vg[107] Vg[108] Vg[109] Vg[10] Vg[110] Vg[111] Vg[11] Vg[12] Vg[13] Vg[14]
+ Vg[15] Vg[16] Vg[17] Vg[18] Vg[19] Vg[1] Vg[20] Vg[21] Vg[22] Vg[23] Vg[24] Vg[25]
+ Vg[26] Vg[27] Vg[28] Vg[29] Vg[2] Vg[30] Vg[31] Vg[32] Vg[33] Vg[34] Vg[35] Vg[36]
+ Vg[37] Vg[38] Vg[39] Vg[3] Vg[40] Vg[41] Vg[42] Vg[43] Vg[44] Vg[45] Vg[46] Vg[47]
+ Vg[48] Vg[49] Vg[4] Vg[50] Vg[51] Vg[52] Vg[53] Vg[54] Vg[55] Vg[56] Vg[57] Vg[58]
+ Vg[59] Vg[5] Vg[60] Vg[61] Vg[62] Vg[63] Vg[64] Vg[65] Vg[66] Vg[67] Vg[68] Vg[69]
+ Vg[6] Vg[70] Vg[71] Vg[72] Vg[73] Vg[74] Vg[75] Vg[76] Vg[77] Vg[78] Vg[79] Vg[7]
+ Vg[80] Vg[81] Vg[82] Vg[83] Vg[84] Vg[85] Vg[86] Vg[87] Vg[88] Vg[89] Vg[8] Vg[90]
+ Vg[91] Vg[92] Vg[93] Vg[94] Vg[95] Vg[96] Vg[97] Vg[98] Vg[99] Vg[9] Vs[0] Vs[100]
+ Vs[101] Vs[102] Vs[103] Vs[104] Vs[105] Vs[106] Vs[107] Vs[108] Vs[109] Vs[10] Vs[110]
+ Vs[111] Vs[11] Vs[12] Vs[13] Vs[14] Vs[15] Vs[16] Vs[17] Vs[18] Vs[19] Vs[1] Vs[20]
+ Vs[21] Vs[22] Vs[23] Vs[24] Vs[25] Vs[26] Vs[27] Vs[28] Vs[29] Vs[2] Vs[30] Vs[31]
+ Vs[32] Vs[33] Vs[34] Vs[35] Vs[36] Vs[37] Vs[38] Vs[39] Vs[3] Vs[40] Vs[41] Vs[42]
+ Vs[43] Vs[44] Vs[45] Vs[46] Vs[47] Vs[48] Vs[49] Vs[4] Vs[50] Vs[51] Vs[52] Vs[53]
+ Vs[54] Vs[55] Vs[56] Vs[57] Vs[58] Vs[59] Vs[5] Vs[60] Vs[61] Vs[62] Vs[63] Vs[64]
+ Vs[65] Vs[66] Vs[67] Vs[68] Vs[69] Vs[6] Vs[70] Vs[71] Vs[72] Vs[73] Vs[74] Vs[75]
+ Vs[76] Vs[77] Vs[78] Vs[79] Vs[7] Vs[80] Vs[81] Vs[82] Vs[83] Vs[84] Vs[85] Vs[86]
+ Vs[87] Vs[88] Vs[89] Vs[8] Vs[90] Vs[91] Vs[92] Vs[93] Vs[94] Vs[95] Vs[96] Vs[97]
+ Vs[98] Vs[99] Vs[9]
Xbondpad_array_g_top_0 Vg[108] Vg[26] Vg[8] Vg[101] Vg[64] Vg[32] Vg[44] Vg[12] Vg[10]
+ Vg[69] Vg[28] Vg[84] Vg[62] Vg[22] Vg[52] Vg[79] Vg[107] Vg[93] Vg[36] Vg[72] Vg[105]
+ Vg[4] Vg[26] Vg[97] Vg[40] Vg[52] Vg[109] Vg[103] Vg[98] Vg[82] Vg[76] Vg[75] Vg[18]
+ Vg[9] Vg[33] Vg[31] Vg[102] Vg[66] Vg[89] Vg[37] Vg[15] Vg[59] Vg[108] Vg[87] Vg[110]
+ Vg[85] Vg[66] Vg[23] Vg[82] Vg[1] Vg[94] Vg[37] Vg[48] Vg[106] Vg[21] Vg[49] Vg[5]
+ Vg[62] Vg[71] Vg[53] Vg[42] Vg[27] Vg[53] Vg[15] Vg[83] Vg[63] Vg[99] Vg[11] Vg[17]
+ Vg[35] Vg[42] Vg[76] Vg[10] Vg[70] Vg[56] Vg[19] Vg[67] Vg[34] Vg[90] Vg[86] Vg[13]
+ Vg[60] Vg[102] Vg[109] Vg[93] Vg[54] Vg[111] Vg[91] Vg[45] Vg[86] Vg[2] Vg[38] Vg[13]
+ Vg[14] Vg[61] Vg[18] Vg[95] Vg[22] Vg[50] Vg[29] Vg[89] Vg[92] Vg[68] Vg[80] Vg[77]
+ Vg[44] Vg[7] Vg[73] Vg[16] Vg[48] Vg[64] Vg[27] Vg[2] Vg[87] Vg[32] Vg[6] Vg[41]
+ Vg[57] Vg[73] Vg[16] Vg[1] Vg[40] Vg[49] Vg[54] Vg[21] Vg[65] Vg[28] Vg[99] Vg[92]
+ Vg[34] Vg[110] Vg[81] Vg[55] Vg[69] Vg[103] Vg[72] Vg[35] Vg[97] Vg[46] Vg[3] Vg[45]
+ Vg[88] Vg[57] Vg[24] Vg[77] Vg[51] Vg[104] Vg[95] Vg[30] Vg[43] Vg[19] Vg[3] Vg[70]
+ Vg[24] Vg[81] Vg[12] Vg[41] Vg[36] Vg[50] Vg[74] Vg[38] Vg[20] Vg[17] Vg[107] Vg[60]
+ Vg[78] Vg[29] Vg[65] Vg[6] Vg[94] Vg[100] Vg[88] Vg[85] Vg[58] Vg[8] Vg[5] Vg[79]
+ Vg[31] Vg[0] Vg[58] Vg[100] Vg[43] li_2407_203029# Vg[46] Vg[25] Vg[56] Vg[96] Vg[0]
+ Vg[4] Vg[106] Vg[105] Vg[11] Vg[20] Vg[68] Vg[111] Vg[75] Vg[104] Vg[39] Vg[84]
+ Vg[47] Vg[14] Vg[23] Vg[51] Vg[63] Vg[61] Vg[55] Vg[78] Vg[91] Vg[67] Vg[30] Vg[7]
+ Vg[101] Vg[83] Vg[9] Vg[71] Vg[98] Vg[25] Vg[74] Vg[80] Vg[47] Vg[90] Vg[96] Vg[59]
+ Vg[33] Vg[39] bondpad_array_g_top
Xpattern_array_small_cs_TOP_LVS_0 Vg[0] Vg[7] Vg[14] Vg[35] Vg[70] Vg[8] Vg[15] Vg[36]
+ Vg[43] Vg[50] Vg[2] Vg[16] Vg[51] Vg[72] Vg[86] Vg[100] Vg[3] Vg[38] Vg[87] Vg[32]
+ Vg[39] Vg[53] Vg[5] Vg[19] Vg[54] Vg[61] Vg[68] Vg[89] Vg[110] Vg[6] Vg[34] Vg[55]
+ Vg[69] Vg[111] Vs[0] Vs[3] Vs[4] Vs[6] Vs[7] Vs[8] Vs[9] Vs[11] Vs[16] Vs[17] Vs[20]
+ Vs[21] Vs[22] Vs[23] Vs[24] Vs[27] Vs[30] Vs[31] Vs[32] Vs[34] Vs[35] Vs[36] Vs[38]
+ Vs[39] Vs[40] Vs[46] Vs[51] Vs[55] Vs[57] Vs[58] Vs[59] Vs[64] Vs[70] Vs[71] Vs[72]
+ Vs[73] Vs[74] Vs[75] Vs[77] Vs[78] Vs[79] Vs[81] Vs[87] Vs[88] Vs[92] Vs[93] Vs[94]
+ Vs[96] Vs[97] Vs[98] Vs[99] Vs[100] Vs[101] Vs[102] Vs[103] Vs[104] Vs[105] Vs[106]
+ Vs[107] Vs[108] Vs[109] Vd Vs[41] Vs[65] Vg[103] Vs[43] Vs[68] Vs[47] Vs[61] Vs[25]
+ Vg[95] Vg[102] Vg[90] Vs[44] Vg[41] Vg[24] Vg[44] Vs[69] Vg[94] Vs[28] Vs[12] Vg[60]
+ Vs[84] Vs[62] Vg[23] Vg[48] Vs[26] Vg[74] Vg[22] Vg[101] Vg[109] Vs[52] Vg[76] Vg[67]
+ Vg[81] Vs[82] Vg[47] Vg[93] Vs[18] Vg[59] Vs[33] Vs[66] Vg[97] Vg[21] Vg[83] Vs[89]
+ Vg[107] Vg[27] Vs[110] Vg[73] Vs[85] Vg[85] Vg[80] Vs[37] Vg[42] Vs[49] Vs[1] Vs[48]
+ Vg[46] Vg[13] Vg[49] Vg[58] Vs[53] Vg[99] Vg[92] Vs[5] Vg[77] Vg[12] Vs[15] Vg[65]
+ Vg[40] Vg[108] Vg[106] Vs[63] Vs[83] Vg[75] Vs[42] Vg[84] Vg[66] Vg[20] Vg[31] Vg[26]
+ Vg[63] Vs[56] Vg[33] Vs[76] Vg[28] Vs[19] Vg[62] Vg[91] Vs[67] Vs[90] Vg[79] Vs[10]
+ Vg[1] Vs[60] Vg[4] Vg[98] Vg[88] Vg[96] Vg[45] Vg[82] Vs[54] Vg[10] Vs[111] Vs[91]
+ Vg[11] Vg[104] Vg[105] Vs[45] Vg[52] Vs[86] Vg[29] Vg[18] Vs[95] Vg[64] Vs[50] Vs[2]
+ Vg[9] Vs[29] Vs[13] Vg[56] Vg[30] Vg[25] Vs[14] Vg[71] Vg[17] Vs[80] Vg[57] Vg[37]
+ Vg[78] pattern_array_small_cs_TOP_LVS
Xbondpad_array_ds_6_top_0 Vs[68] Vs[49] Vs[99] Vs[45] Vs[72] Vs[2] Vs[3] Vs[57] Vs[41]
+ Vs[19] li_2407_203029# Vs[50] Vs[29] Vs[78] Vs[94] Vs[58] Vs[25] Vs[46] Vs[75] Vs[39]
+ Vs[23] Vs[30] Vs[101] Vs[9] Vs[1] Vs[7] Vs[105] Vs[98] Vs[74] Vs[110] Vs[97] Vs[90]
+ Vs[14] Vs[85] Vs[56] Vs[51] Vs[26] Vs[64] Vs[102] Vs[10] Vs[80] Vs[81] Vs[96] Vs[48]
+ Vs[60] Vs[36] Vs[5] Vs[6] Vs[20] Vs[44] Vs[53] Vs[28] Vs[65] Vs[106] Vs[77] Vs[32]
+ Vs[111] Vs[103] Vs[93] Vs[84] Vs[69] Vs[59] Vs[91] Vs[61] Vs[100] Vs[76] Vs[47]
+ Vs[37] Vs[108] Vs[16] Vs[31] Vs[40] Vs[52] Vs[15] Vs[87] Vs[54] Vs[24] Vs[33] Vs[66]
+ Vs[8] Vs[104] Vs[12] Vs[4] Vs[82] Vs[73] Vs[83] Vs[21] Vs[92] Vs[0] Vs[89] Vs[71]
+ Vs[107] Vs[38] Vs[109] Vs[18] Vs[17] Vs[27] Vs[42] Vs[88] Vs[35] Vs[63] Vs[11] Vs[62]
+ Vs[55] Vs[67] Vs[34] Vs[79] Vs[43] Vs[70] Vs[13] Vs[22] Vs[95] Vs[86] bondpad_array_ds_6_top
.ends

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[7] io_analog[8] io_analog[9] io_analog[4]
+ io_analog[5] io_analog[6] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vdda1 vdda2 vssa1 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
XTOPLEVEL_2_LVSCLEAN_0 TOPLEVEL_2_LVSCLEAN_0/Vd TOPLEVEL_2_LVSCLEAN_0/Vg[0] TOPLEVEL_2_LVSCLEAN_0/Vg[100]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[101] TOPLEVEL_2_LVSCLEAN_0/Vg[102] TOPLEVEL_2_LVSCLEAN_0/Vg[103]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[104] TOPLEVEL_2_LVSCLEAN_0/Vg[105] TOPLEVEL_2_LVSCLEAN_0/Vg[106]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[107] TOPLEVEL_2_LVSCLEAN_0/Vg[108] TOPLEVEL_2_LVSCLEAN_0/Vg[109]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[10] TOPLEVEL_2_LVSCLEAN_0/Vg[110] TOPLEVEL_2_LVSCLEAN_0/Vg[111]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[11] TOPLEVEL_2_LVSCLEAN_0/Vg[12] TOPLEVEL_2_LVSCLEAN_0/Vg[13]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[14] TOPLEVEL_2_LVSCLEAN_0/Vg[15] TOPLEVEL_2_LVSCLEAN_0/Vg[16]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[17] TOPLEVEL_2_LVSCLEAN_0/Vg[18] TOPLEVEL_2_LVSCLEAN_0/Vg[19]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[1] TOPLEVEL_2_LVSCLEAN_0/Vg[20] TOPLEVEL_2_LVSCLEAN_0/Vg[21]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[22] TOPLEVEL_2_LVSCLEAN_0/Vg[23] TOPLEVEL_2_LVSCLEAN_0/Vg[24]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[25] TOPLEVEL_2_LVSCLEAN_0/Vg[26] TOPLEVEL_2_LVSCLEAN_0/Vg[27]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[28] TOPLEVEL_2_LVSCLEAN_0/Vg[29] TOPLEVEL_2_LVSCLEAN_0/Vg[2]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[30] TOPLEVEL_2_LVSCLEAN_0/Vg[31] TOPLEVEL_2_LVSCLEAN_0/Vg[32]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[33] TOPLEVEL_2_LVSCLEAN_0/Vg[34] TOPLEVEL_2_LVSCLEAN_0/Vg[35]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[36] TOPLEVEL_2_LVSCLEAN_0/Vg[37] TOPLEVEL_2_LVSCLEAN_0/Vg[38]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[39] TOPLEVEL_2_LVSCLEAN_0/Vg[3] TOPLEVEL_2_LVSCLEAN_0/Vg[40]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[41] TOPLEVEL_2_LVSCLEAN_0/Vg[42] TOPLEVEL_2_LVSCLEAN_0/Vg[43]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[44] TOPLEVEL_2_LVSCLEAN_0/Vg[45] TOPLEVEL_2_LVSCLEAN_0/Vg[46]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[47] TOPLEVEL_2_LVSCLEAN_0/Vg[48] TOPLEVEL_2_LVSCLEAN_0/Vg[49]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[4] TOPLEVEL_2_LVSCLEAN_0/Vg[50] TOPLEVEL_2_LVSCLEAN_0/Vg[51]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[52] TOPLEVEL_2_LVSCLEAN_0/Vg[53] TOPLEVEL_2_LVSCLEAN_0/Vg[54]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[55] TOPLEVEL_2_LVSCLEAN_0/Vg[56] TOPLEVEL_2_LVSCLEAN_0/Vg[57]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[58] TOPLEVEL_2_LVSCLEAN_0/Vg[59] TOPLEVEL_2_LVSCLEAN_0/Vg[5]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[60] TOPLEVEL_2_LVSCLEAN_0/Vg[61] TOPLEVEL_2_LVSCLEAN_0/Vg[62]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[63] TOPLEVEL_2_LVSCLEAN_0/Vg[64] TOPLEVEL_2_LVSCLEAN_0/Vg[65]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[66] TOPLEVEL_2_LVSCLEAN_0/Vg[67] TOPLEVEL_2_LVSCLEAN_0/Vg[68]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[69] TOPLEVEL_2_LVSCLEAN_0/Vg[6] TOPLEVEL_2_LVSCLEAN_0/Vg[70]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[71] TOPLEVEL_2_LVSCLEAN_0/Vg[72] TOPLEVEL_2_LVSCLEAN_0/Vg[73]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[74] TOPLEVEL_2_LVSCLEAN_0/Vg[75] TOPLEVEL_2_LVSCLEAN_0/Vg[76]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[77] TOPLEVEL_2_LVSCLEAN_0/Vg[78] TOPLEVEL_2_LVSCLEAN_0/Vg[79]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[7] TOPLEVEL_2_LVSCLEAN_0/Vg[80] TOPLEVEL_2_LVSCLEAN_0/Vg[81]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[82] TOPLEVEL_2_LVSCLEAN_0/Vg[83] TOPLEVEL_2_LVSCLEAN_0/Vg[84]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[85] TOPLEVEL_2_LVSCLEAN_0/Vg[86] TOPLEVEL_2_LVSCLEAN_0/Vg[87]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[88] TOPLEVEL_2_LVSCLEAN_0/Vg[89] TOPLEVEL_2_LVSCLEAN_0/Vg[8]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[90] TOPLEVEL_2_LVSCLEAN_0/Vg[91] TOPLEVEL_2_LVSCLEAN_0/Vg[92]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[93] TOPLEVEL_2_LVSCLEAN_0/Vg[94] TOPLEVEL_2_LVSCLEAN_0/Vg[95]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[96] TOPLEVEL_2_LVSCLEAN_0/Vg[97] TOPLEVEL_2_LVSCLEAN_0/Vg[98]
+ TOPLEVEL_2_LVSCLEAN_0/Vg[99] TOPLEVEL_2_LVSCLEAN_0/Vg[9] TOPLEVEL_2_LVSCLEAN_0/Vs[0]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[100] TOPLEVEL_2_LVSCLEAN_0/Vs[101] TOPLEVEL_2_LVSCLEAN_0/Vs[102]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[103] TOPLEVEL_2_LVSCLEAN_0/Vs[104] TOPLEVEL_2_LVSCLEAN_0/Vs[105]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[106] TOPLEVEL_2_LVSCLEAN_0/Vs[107] TOPLEVEL_2_LVSCLEAN_0/Vs[108]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[109] TOPLEVEL_2_LVSCLEAN_0/Vs[10] TOPLEVEL_2_LVSCLEAN_0/Vs[110]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[111] TOPLEVEL_2_LVSCLEAN_0/Vs[11] TOPLEVEL_2_LVSCLEAN_0/Vs[12]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[13] TOPLEVEL_2_LVSCLEAN_0/Vs[14] TOPLEVEL_2_LVSCLEAN_0/Vs[15]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[16] TOPLEVEL_2_LVSCLEAN_0/Vs[17] TOPLEVEL_2_LVSCLEAN_0/Vs[18]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[19] TOPLEVEL_2_LVSCLEAN_0/Vs[1] TOPLEVEL_2_LVSCLEAN_0/Vs[20]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[21] TOPLEVEL_2_LVSCLEAN_0/Vs[22] TOPLEVEL_2_LVSCLEAN_0/Vs[23]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[24] TOPLEVEL_2_LVSCLEAN_0/Vs[25] TOPLEVEL_2_LVSCLEAN_0/Vs[26]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[27] TOPLEVEL_2_LVSCLEAN_0/Vs[28] TOPLEVEL_2_LVSCLEAN_0/Vs[29]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[2] TOPLEVEL_2_LVSCLEAN_0/Vs[30] TOPLEVEL_2_LVSCLEAN_0/Vs[31]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[32] TOPLEVEL_2_LVSCLEAN_0/Vs[33] TOPLEVEL_2_LVSCLEAN_0/Vs[34]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[35] TOPLEVEL_2_LVSCLEAN_0/Vs[36] TOPLEVEL_2_LVSCLEAN_0/Vs[37]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[38] TOPLEVEL_2_LVSCLEAN_0/Vs[39] TOPLEVEL_2_LVSCLEAN_0/Vs[3]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[40] TOPLEVEL_2_LVSCLEAN_0/Vs[41] TOPLEVEL_2_LVSCLEAN_0/Vs[42]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[43] TOPLEVEL_2_LVSCLEAN_0/Vs[44] TOPLEVEL_2_LVSCLEAN_0/Vs[45]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[46] TOPLEVEL_2_LVSCLEAN_0/Vs[47] TOPLEVEL_2_LVSCLEAN_0/Vs[48]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[49] TOPLEVEL_2_LVSCLEAN_0/Vs[4] TOPLEVEL_2_LVSCLEAN_0/Vs[50]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[51] TOPLEVEL_2_LVSCLEAN_0/Vs[52] TOPLEVEL_2_LVSCLEAN_0/Vs[53]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[54] TOPLEVEL_2_LVSCLEAN_0/Vs[55] TOPLEVEL_2_LVSCLEAN_0/Vs[56]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[57] TOPLEVEL_2_LVSCLEAN_0/Vs[58] TOPLEVEL_2_LVSCLEAN_0/Vs[59]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[5] TOPLEVEL_2_LVSCLEAN_0/Vs[60] TOPLEVEL_2_LVSCLEAN_0/Vs[61]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[62] TOPLEVEL_2_LVSCLEAN_0/Vs[63] TOPLEVEL_2_LVSCLEAN_0/Vs[64]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[65] TOPLEVEL_2_LVSCLEAN_0/Vs[66] TOPLEVEL_2_LVSCLEAN_0/Vs[67]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[68] TOPLEVEL_2_LVSCLEAN_0/Vs[69] TOPLEVEL_2_LVSCLEAN_0/Vs[6]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[70] TOPLEVEL_2_LVSCLEAN_0/Vs[71] TOPLEVEL_2_LVSCLEAN_0/Vs[72]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[73] TOPLEVEL_2_LVSCLEAN_0/Vs[74] TOPLEVEL_2_LVSCLEAN_0/Vs[75]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[76] TOPLEVEL_2_LVSCLEAN_0/Vs[77] TOPLEVEL_2_LVSCLEAN_0/Vs[78]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[79] TOPLEVEL_2_LVSCLEAN_0/Vs[7] TOPLEVEL_2_LVSCLEAN_0/Vs[80]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[81] TOPLEVEL_2_LVSCLEAN_0/Vs[82] TOPLEVEL_2_LVSCLEAN_0/Vs[83]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[84] TOPLEVEL_2_LVSCLEAN_0/Vs[85] TOPLEVEL_2_LVSCLEAN_0/Vs[86]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[87] TOPLEVEL_2_LVSCLEAN_0/Vs[88] TOPLEVEL_2_LVSCLEAN_0/Vs[89]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[8] TOPLEVEL_2_LVSCLEAN_0/Vs[90] TOPLEVEL_2_LVSCLEAN_0/Vs[91]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[92] TOPLEVEL_2_LVSCLEAN_0/Vs[93] TOPLEVEL_2_LVSCLEAN_0/Vs[94]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[95] TOPLEVEL_2_LVSCLEAN_0/Vs[96] TOPLEVEL_2_LVSCLEAN_0/Vs[97]
+ TOPLEVEL_2_LVSCLEAN_0/Vs[98] TOPLEVEL_2_LVSCLEAN_0/Vs[99] TOPLEVEL_2_LVSCLEAN_0/Vs[9]
+ TOPLEVEL_2_LVSCLEAN
XTOPLEVEL_2_LVSCLEAN_1 TOPLEVEL_2_LVSCLEAN_1/Vd TOPLEVEL_2_LVSCLEAN_1/Vg[0] TOPLEVEL_2_LVSCLEAN_1/Vg[100]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[101] TOPLEVEL_2_LVSCLEAN_1/Vg[102] TOPLEVEL_2_LVSCLEAN_1/Vg[103]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[104] TOPLEVEL_2_LVSCLEAN_1/Vg[105] TOPLEVEL_2_LVSCLEAN_1/Vg[106]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[107] TOPLEVEL_2_LVSCLEAN_1/Vg[108] TOPLEVEL_2_LVSCLEAN_1/Vg[109]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[10] TOPLEVEL_2_LVSCLEAN_1/Vg[110] TOPLEVEL_2_LVSCLEAN_1/Vg[111]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[11] TOPLEVEL_2_LVSCLEAN_1/Vg[12] TOPLEVEL_2_LVSCLEAN_1/Vg[13]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[14] TOPLEVEL_2_LVSCLEAN_1/Vg[15] TOPLEVEL_2_LVSCLEAN_1/Vg[16]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[17] TOPLEVEL_2_LVSCLEAN_1/Vg[18] TOPLEVEL_2_LVSCLEAN_1/Vg[19]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[1] TOPLEVEL_2_LVSCLEAN_1/Vg[20] TOPLEVEL_2_LVSCLEAN_1/Vg[21]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[22] TOPLEVEL_2_LVSCLEAN_1/Vg[23] TOPLEVEL_2_LVSCLEAN_1/Vg[24]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[25] TOPLEVEL_2_LVSCLEAN_1/Vg[26] TOPLEVEL_2_LVSCLEAN_1/Vg[27]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[28] TOPLEVEL_2_LVSCLEAN_1/Vg[29] TOPLEVEL_2_LVSCLEAN_1/Vg[2]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[30] TOPLEVEL_2_LVSCLEAN_1/Vg[31] TOPLEVEL_2_LVSCLEAN_1/Vg[32]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[33] TOPLEVEL_2_LVSCLEAN_1/Vg[34] TOPLEVEL_2_LVSCLEAN_1/Vg[35]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[36] TOPLEVEL_2_LVSCLEAN_1/Vg[37] TOPLEVEL_2_LVSCLEAN_1/Vg[38]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[39] TOPLEVEL_2_LVSCLEAN_1/Vg[3] TOPLEVEL_2_LVSCLEAN_1/Vg[40]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[41] TOPLEVEL_2_LVSCLEAN_1/Vg[42] TOPLEVEL_2_LVSCLEAN_1/Vg[43]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[44] TOPLEVEL_2_LVSCLEAN_1/Vg[45] TOPLEVEL_2_LVSCLEAN_1/Vg[46]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[47] TOPLEVEL_2_LVSCLEAN_1/Vg[48] TOPLEVEL_2_LVSCLEAN_1/Vg[49]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[4] TOPLEVEL_2_LVSCLEAN_1/Vg[50] TOPLEVEL_2_LVSCLEAN_1/Vg[51]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[52] TOPLEVEL_2_LVSCLEAN_1/Vg[53] TOPLEVEL_2_LVSCLEAN_1/Vg[54]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[55] TOPLEVEL_2_LVSCLEAN_1/Vg[56] TOPLEVEL_2_LVSCLEAN_1/Vg[57]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[58] TOPLEVEL_2_LVSCLEAN_1/Vg[59] TOPLEVEL_2_LVSCLEAN_1/Vg[5]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[60] TOPLEVEL_2_LVSCLEAN_1/Vg[61] TOPLEVEL_2_LVSCLEAN_1/Vg[62]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[63] TOPLEVEL_2_LVSCLEAN_1/Vg[64] TOPLEVEL_2_LVSCLEAN_1/Vg[65]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[66] TOPLEVEL_2_LVSCLEAN_1/Vg[67] TOPLEVEL_2_LVSCLEAN_1/Vg[68]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[69] TOPLEVEL_2_LVSCLEAN_1/Vg[6] TOPLEVEL_2_LVSCLEAN_1/Vg[70]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[71] TOPLEVEL_2_LVSCLEAN_1/Vg[72] TOPLEVEL_2_LVSCLEAN_1/Vg[73]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[74] TOPLEVEL_2_LVSCLEAN_1/Vg[75] TOPLEVEL_2_LVSCLEAN_1/Vg[76]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[77] TOPLEVEL_2_LVSCLEAN_1/Vg[78] TOPLEVEL_2_LVSCLEAN_1/Vg[79]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[7] TOPLEVEL_2_LVSCLEAN_1/Vg[80] TOPLEVEL_2_LVSCLEAN_1/Vg[81]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[82] TOPLEVEL_2_LVSCLEAN_1/Vg[83] TOPLEVEL_2_LVSCLEAN_1/Vg[84]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[85] TOPLEVEL_2_LVSCLEAN_1/Vg[86] TOPLEVEL_2_LVSCLEAN_1/Vg[87]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[88] TOPLEVEL_2_LVSCLEAN_1/Vg[89] TOPLEVEL_2_LVSCLEAN_1/Vg[8]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[90] TOPLEVEL_2_LVSCLEAN_1/Vg[91] TOPLEVEL_2_LVSCLEAN_1/Vg[92]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[93] TOPLEVEL_2_LVSCLEAN_1/Vg[94] TOPLEVEL_2_LVSCLEAN_1/Vg[95]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[96] TOPLEVEL_2_LVSCLEAN_1/Vg[97] TOPLEVEL_2_LVSCLEAN_1/Vg[98]
+ TOPLEVEL_2_LVSCLEAN_1/Vg[99] TOPLEVEL_2_LVSCLEAN_1/Vg[9] TOPLEVEL_2_LVSCLEAN_1/Vs[0]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[100] TOPLEVEL_2_LVSCLEAN_1/Vs[101] TOPLEVEL_2_LVSCLEAN_1/Vs[102]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[103] TOPLEVEL_2_LVSCLEAN_1/Vs[104] TOPLEVEL_2_LVSCLEAN_1/Vs[105]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[106] TOPLEVEL_2_LVSCLEAN_1/Vs[107] TOPLEVEL_2_LVSCLEAN_1/Vs[108]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[109] TOPLEVEL_2_LVSCLEAN_1/Vs[10] TOPLEVEL_2_LVSCLEAN_1/Vs[110]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[111] TOPLEVEL_2_LVSCLEAN_1/Vs[11] TOPLEVEL_2_LVSCLEAN_1/Vs[12]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[13] TOPLEVEL_2_LVSCLEAN_1/Vs[14] TOPLEVEL_2_LVSCLEAN_1/Vs[15]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[16] TOPLEVEL_2_LVSCLEAN_1/Vs[17] TOPLEVEL_2_LVSCLEAN_1/Vs[18]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[19] TOPLEVEL_2_LVSCLEAN_1/Vs[1] TOPLEVEL_2_LVSCLEAN_1/Vs[20]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[21] TOPLEVEL_2_LVSCLEAN_1/Vs[22] TOPLEVEL_2_LVSCLEAN_1/Vs[23]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[24] TOPLEVEL_2_LVSCLEAN_1/Vs[25] TOPLEVEL_2_LVSCLEAN_1/Vs[26]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[27] TOPLEVEL_2_LVSCLEAN_1/Vs[28] TOPLEVEL_2_LVSCLEAN_1/Vs[29]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[2] TOPLEVEL_2_LVSCLEAN_1/Vs[30] TOPLEVEL_2_LVSCLEAN_1/Vs[31]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[32] TOPLEVEL_2_LVSCLEAN_1/Vs[33] TOPLEVEL_2_LVSCLEAN_1/Vs[34]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[35] TOPLEVEL_2_LVSCLEAN_1/Vs[36] TOPLEVEL_2_LVSCLEAN_1/Vs[37]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[38] TOPLEVEL_2_LVSCLEAN_1/Vs[39] TOPLEVEL_2_LVSCLEAN_1/Vs[3]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[40] TOPLEVEL_2_LVSCLEAN_1/Vs[41] TOPLEVEL_2_LVSCLEAN_1/Vs[42]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[43] TOPLEVEL_2_LVSCLEAN_1/Vs[44] TOPLEVEL_2_LVSCLEAN_1/Vs[45]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[46] TOPLEVEL_2_LVSCLEAN_1/Vs[47] TOPLEVEL_2_LVSCLEAN_1/Vs[48]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[49] TOPLEVEL_2_LVSCLEAN_1/Vs[4] TOPLEVEL_2_LVSCLEAN_1/Vs[50]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[51] TOPLEVEL_2_LVSCLEAN_1/Vs[52] TOPLEVEL_2_LVSCLEAN_1/Vs[53]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[54] TOPLEVEL_2_LVSCLEAN_1/Vs[55] TOPLEVEL_2_LVSCLEAN_1/Vs[56]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[57] TOPLEVEL_2_LVSCLEAN_1/Vs[58] TOPLEVEL_2_LVSCLEAN_1/Vs[59]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[5] TOPLEVEL_2_LVSCLEAN_1/Vs[60] TOPLEVEL_2_LVSCLEAN_1/Vs[61]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[62] TOPLEVEL_2_LVSCLEAN_1/Vs[63] TOPLEVEL_2_LVSCLEAN_1/Vs[64]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[65] TOPLEVEL_2_LVSCLEAN_1/Vs[66] TOPLEVEL_2_LVSCLEAN_1/Vs[67]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[68] TOPLEVEL_2_LVSCLEAN_1/Vs[69] TOPLEVEL_2_LVSCLEAN_1/Vs[6]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[70] TOPLEVEL_2_LVSCLEAN_1/Vs[71] TOPLEVEL_2_LVSCLEAN_1/Vs[72]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[73] TOPLEVEL_2_LVSCLEAN_1/Vs[74] TOPLEVEL_2_LVSCLEAN_1/Vs[75]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[76] TOPLEVEL_2_LVSCLEAN_1/Vs[77] TOPLEVEL_2_LVSCLEAN_1/Vs[78]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[79] TOPLEVEL_2_LVSCLEAN_1/Vs[7] TOPLEVEL_2_LVSCLEAN_1/Vs[80]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[81] TOPLEVEL_2_LVSCLEAN_1/Vs[82] TOPLEVEL_2_LVSCLEAN_1/Vs[83]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[84] TOPLEVEL_2_LVSCLEAN_1/Vs[85] TOPLEVEL_2_LVSCLEAN_1/Vs[86]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[87] TOPLEVEL_2_LVSCLEAN_1/Vs[88] TOPLEVEL_2_LVSCLEAN_1/Vs[89]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[8] TOPLEVEL_2_LVSCLEAN_1/Vs[90] TOPLEVEL_2_LVSCLEAN_1/Vs[91]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[92] TOPLEVEL_2_LVSCLEAN_1/Vs[93] TOPLEVEL_2_LVSCLEAN_1/Vs[94]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[95] TOPLEVEL_2_LVSCLEAN_1/Vs[96] TOPLEVEL_2_LVSCLEAN_1/Vs[97]
+ TOPLEVEL_2_LVSCLEAN_1/Vs[98] TOPLEVEL_2_LVSCLEAN_1/Vs[99] TOPLEVEL_2_LVSCLEAN_1/Vs[9]
+ TOPLEVEL_2_LVSCLEAN
.ends
